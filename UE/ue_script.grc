options:
  parameters:
    generate_options: qt_gui
    id: ue_script
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '945000000'
  states: {}
- name: center_freq_0
  id: variable_qtgui_entry
  parameters:
    label: USRP Central Frequency (Hz)
    type: int
    value: '945000000'
  states: {}
- name: gain_rx
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '0'
  states: {}
- name: gain_tx
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '50'
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: '65000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {state: disabled}
- name: blocks_rms_xx_1
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Ones',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.set_tag_propagation_policy(gr.TPP_ONE_TO_ONE)

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = (input_items[0] * 0 ) + 1
              return len(output_items[0])
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[(np.complex64, 1024)],
                  out_sig=[np.float32]
              )

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = (np.sum(np.abs(input_items[0][:])**2)/len(input_items[0][:]))
              return len(output_items[0])
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    depth: payload_len
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: pdu_random_pdu_0_0
  id: pdu_random_pdu
  parameters:
    length_modulo: payload_len
    mask: '0x01'
    maxsize: payload_len
    minsize: payload_len
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    key: pmt.intern("#t")
    label: Send Calibration Frame
    type: string
    value: pmt.intern("#t")
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    dev_addr: '"addr=192.168.10.2"'
    gain0: gain_tx
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    clock_source0: gpsdo
    dc_offs_enb0: auto
    dev_addr: '"addr=192.168.10.2"'
    gain0: gain_rx
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://10.10.8.34:5678
    timeout: '100'
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://10.10.8.27:5678
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', uhd_usrp_sink_0, '0']
- [blocks_float_to_complex_0, '0', epy_block_0, '0']
- [blocks_rms_xx_1, '0', qtgui_number_sink_0, '0']
- [blocks_rms_xx_1, '0', zeromq_push_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_float_to_complex_0, '0']
- [epy_block_0, '0', uhd_usrp_sink_0, '0']
- [epy_block_0_0, '0', qtgui_number_sink_0, '0']
- [epy_block_0_0, '0', zeromq_push_sink_0, '0']
- [fft_vxx_0, '0', epy_block_0_0, '0']
- [pdu_pdu_to_stream_x_0, '0', blocks_uchar_to_float_0, '0']
- [pdu_random_pdu_0_0, pdus, pdu_pdu_to_stream_x_0, pdus]
- [qtgui_edit_box_msg_0, msg, pdu_random_pdu_0_0, generate]
- [uhd_usrp_source_0, '0', blocks_rms_xx_1, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [zeromq_pull_msg_source_0, out, pdu_random_pdu_0_0, generate]

metadata:
  file_format: 1
