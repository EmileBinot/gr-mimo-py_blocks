options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: angle
  id: variable_qtgui_range
  parameters:
    start: '-90'
    step: '45'
    stop: '90'
    value: '-90'
  states: {state: disabled}
- name: angle
  id: variable
  parameters:
    value: python_mod.sweeper(fun_prob)
  states: {state: disabled}
- name: center_freq
  id: variable
  parameters:
    value: '945000000'
  states: {}
- name: chooser
  id: variable_qtgui_chooser
  parameters:
    gui_hint: '(0, 1, 1, 5) '
    label: Choose State
    label0: Rx cal
    label1: AoA Estimation
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: fun_prob
  id: variable_function_probe
  parameters:
    block_id: probSign
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {state: disabled}
- name: gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: '65000'
  states: {}
- name: push_button
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'False'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {state: disabled}
- name: push_button
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'False'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0.5'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: ang
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '-180'
    name: '"Angle"'
    type: float
  states: {state: disabled}
- name: blocks_complex_to_real_0_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_1_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_1_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_1_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_copy_0_0
  id: blocks_copy
  parameters:
    enabled: push_button
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: beam_trace
    type: float
  states: {state: disabled}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: chooser
    type: complex
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (1, 1)
    type: complex
  states: {}
- name: blocks_stream_demux_0_0
  id: blocks_stream_demux
  parameters:
    lengths: (1, 1)
    type: complex
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: float
  states: {state: disabled}
- name: blocks_stream_mux_0_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: complex
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, angle=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32, np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.angle = angle

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0]
              output_items[1][:] = self.angle
              return len(output_items[0])
    angle: angle
  states: {state: disabled}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, num_samples_to_process = 10000, threshold = 0.01):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='SiMo AoA Calculation',   # will show up in GRC
                  in_sig=[np.complex64,np.complex64],
                  out_sig=[np.float32]
              )
              self.num_samples_to_count = num_samples_to_process
              self.set_output_multiple(self.num_samples_to_count)
              self.threshold = threshold

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              angles = np.arange(-np.pi,np.pi,np.pi/180)
              sum = []
              
              in0 = input_items[0][:100]
              in1 = input_items[1][:100]

              if np.mean(np.abs(in0)) > self.threshold :
                  for theta in angles:
                      sum.append(np.mean(np.abs(in0 * np.exp(-1j*theta) + in1 * np.exp(-1j*theta))))
                  
                  max_idx = np.argmax(sum)

                  output_items[0][:] = np.degrees(angles[max_idx])
              return len(output_items[0])
    num_samples_to_process: samp_rate*2
    threshold: '0.1'
  states: {}
- name: epy_block_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, num_samples_to_process = 10000, threshold = 0.01):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='PLLs phase shift detector',   # will show up in GRC
                  in_sig=[np.complex64,np.complex64],
                  out_sig=[np.complex64,np.complex64,np.float32]
              )
              self.message_port_register_out(pmt.intern("phase_diff"))
              self.num_samples_to_count = num_samples_to_process
              self.counter = 0
              self.set_output_multiple(self.num_samples_to_count)
              self.threshold = threshold

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              # print("call")
              output_items[0][:] = input_items[0] 
              output_items[1][:] = input_items[1]
              
              angles = np.arange(-np.pi,np.pi,np.pi/180)
              sum = []
              
              in0 = input_items[0][:100]
              in1 = input_items[1][:100]
              if np.mean(np.abs(in0)) > self.threshold :
                  for theta in angles:
                      sum.append(np.mean(np.abs(in0 + in1 * np.exp(-1j*theta))))
                  
                  max_idx = np.argmax(sum)

                  PMT_msg = pmt.from_float(angles[max_idx])
                  self.message_port_pub(pmt.intern("phase_diff"), PMT_msg)

                  output_items[2][:] = np.degrees(angles[max_idx])
              return len(output_items[0])
    num_samples_to_process: samp_rate*2
    threshold: '0.05'
  states: {}
- name: epy_block_0_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='ones',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = (input_items[0] * 0 ) + 1
              return len(output_items[0])
  states: {state: disabled}
- name: epy_block_0_3_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      def NormalizeData(data):
          return (data - np.min(data)) / (np.max(data) - np.min(data))

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Phase Compensation',   # will show up in GRC
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[np.complex64, np.complex64]
              )
              self.message_port_register_in(pmt.intern("phase_diff"))
              self.set_msg_handler(pmt.intern("phase_diff"), self.handle_msg)
              self.phase_diff = 0
              self.set_tag_propagation_policy(gr.TPP_ONE_TO_ONE)
          
          def handle_msg(self, msg):  
              self.phase_diff = pmt.to_float(msg)
              # print(self.phase_diff)

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0]
              output_items[1][:] = input_items[1] * np.exp(-1j*self.phase_diff)
              return len(output_items[0])
  states: {state: disabled}
- name: epy_block_0_3_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      def NormalizeData(data):
          return (data - np.min(data)) / (np.max(data) - np.min(data))

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Phase Compensation',   # will show up in GRC
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[np.complex64, np.complex64]
              )
              self.message_port_register_in(pmt.intern("phase_diff"))
              self.set_msg_handler(pmt.intern("phase_diff"), self.handle_msg)
              self.phase_diff = 0
              self.set_tag_propagation_policy(gr.TPP_ONE_TO_ONE)
          
          def handle_msg(self, msg):  
              self.phase_diff = pmt.to_float(msg)
              # print(self.phase_diff)

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0]
              output_items[1][:] = input_items[1] * np.exp(-1j*self.phase_diff)
              return len(output_items[0])
  states: {}
- name: epy_block_0_3_0_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      def NormalizeData(data):
          return (data - np.min(data)) / (np.max(data) - np.min(data))

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Phase Compensation',   # will show up in GRC
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[np.complex64, np.complex64]
              )
              self.message_port_register_in(pmt.intern("phase_diff"))
              self.set_msg_handler(pmt.intern("phase_diff"), self.handle_msg)
              self.phase_diff = 0
              self.set_tag_propagation_policy(gr.TPP_ONE_TO_ONE)
          
          def handle_msg(self, msg):  
              self.phase_diff = pmt.to_float(msg)
              # print(self.phase_diff)

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0]
              output_items[1][:] = input_items[1] * np.exp(-1j*self.phase_diff)
              return len(output_items[0])
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      DBS
      """

      import numpy as np
      from gnuradio import gr
      import math

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, angle=0.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='DBS precoder',   # will show up in GRC
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[np.complex64, np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.angle = angle  # [-90 -> 90]

          def work(self, input_items, output_items):

              # self.F = np.transpose([np.exp(-1j*math.pi*math.sin(self.angle*math.pi/180)*np.arange(1,2+1))]) * (1/math.sqrt(2))
              # x = [np.transpose(input_items[0])]
              # x_precoded = np.matmul(self.F, x)
              # output_items[0][:] = x_precoded[0]
              # output_items[1][:] = x_precoded[1]
              output_items[0][:] = input_items[0]
              output_items[1][:] = input_items[1]*np.exp(1j*np.cos(self.angle*math.pi/180))
              return len(output_items[0])
    angle: angle
  states: {state: disabled}
- name: pdu_pdu_to_stream_x_0_0
  id: pdu_pdu_to_stream_x
  parameters:
    depth: payload_len
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {state: disabled}
- name: pdu_random_pdu_0_0_0
  id: pdu_random_pdu
  parameters:
    length_modulo: payload_len
    mask: '0x01'
    maxsize: payload_len
    minsize: payload_len
  states: {state: disabled}
- name: probSign
  id: blocks_probe_signal_x
  parameters:
    type: complex
  states: {state: disabled}
- name: pwr
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '100'
    min: '0'
    name: '"Power Received"'
    type: float
  states: {state: disabled}
- name: python_mod
  id: epy_module
  parameters:
    source_code: |-
      # this module will be imported in the into your flowgraph

      an1=-180
      an2=180
      angle = an1

      step = 11.25

      def sweeper(prob_lvl) : 
          global an1,an2,angle, step
          if prob_lvl :
              angle += step

          if angle > an2 :
              angle = an1

          return angle
  states: {state: disabled}
- name: qtgui_compass_0
  id: qtgui_compass
  parameters:
    backgroundColor: silver
    fullNeedle: '2'
    gui_hint: '(5, 3, 2, 3) '
    min_size: '250'
    name: AoA Estimation
  states: {}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    key: pmt.intern("#t")
    label: Send DBS frame
    type: string
    value: pmt.intern("#t")
  states: {state: disabled}
- name: qtgui_edit_box_msg_0_0_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: '(9, 0, 1, 3) '
    is_pair: 'False'
    key: pmt.intern("#t")
    label: Send Rx cal frame
    type: string
    value: pmt.intern("#t")
  states: {}
- name: qtgui_edit_box_msg_0_0_0_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: '(9, 3, 1, 3) '
    is_pair: 'False'
    key: pmt.intern("#t")
    label: Send frame
    type: string
    value: pmt.intern("#t")
  states: {}
- name: qtgui_ledindicator_0_0_1
  id: qtgui_ledindicator
  parameters:
    gui_hint: '(2,3, 1, 1) '
    label: '"AoA Estimation"'
    offColor: silver
    state: chooser == 1
  states: {}
- name: qtgui_ledindicator_0_1
  id: qtgui_ledindicator
  parameters:
    gui_hint: '(2, 0, 1, 1) '
    label: '"Rx Calibration"'
    offColor: silver
    state: chooser == 0
  states: {}
- name: qtgui_number_sink_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: '(8, 0, 1, 3) '
    label1: 'Phase Shift :'
    max: '180'
    min: '-180'
    name: '"Phase Difference between USRPs Rx PLLs (degrees)"'
    type: float
    unit1: °
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: '(3,3,2, 3) '
    label1: Ant 0
    label2: Ant 1
    name: '"Phase shift compensated, AoA estimation"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    width1: '2'
    width2: '2'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    alpha1: '2.0'
    alpha2: '2.0'
    entags: 'False'
    gui_hint: '(3, 0,2, 3) '
    label1: Ant 0
    label2: Ant 1
    name: '"Received signal"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    width1: '2'
    width2: '2'
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '2.0'
    alpha2: '2.0'
    entags: 'False'
    gui_hint: '(5, 0, 2, 3) '
    label1: Ant 0
    label2: Ant 1
    name: '"Rx PLLs Calibrated"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    width1: '2'
    width2: '2'
  states: {}
- name: uhd_usrp_sink_0_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: center_freq
    center_freq1: center_freq
    clock_source0: gpsdo
    clock_source1: mimo
    dev_addr: '"addr0=192.168.10.3, addr1=192.168.10.2"'
    gain0: gain
    gain1: gain
    nchan: '2'
    num_mboards: '2'
    samp_rate: samp_rate
    sync: none
    time_source1: mimo
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: center_freq
    center_freq1: center_freq
    clock_source0: gpsdo
    clock_source1: mimo
    dev_addr: '"addr0=192.168.10.3, addr1=192.168.10.2"'
    gain0: '9'
    gain1: '9'
    nchan: '2'
    num_mboards: '2'
    samp_rate: samp_rate*10
    sync: none
    time_source1: mimo
    type: fc32
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://10.10.8.27:5678
    timeout: '100'
    type: float
  states: {state: disabled}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://10.10.8.34:5678
    timeout: '100'
  states: {}

connections:
- [analog_sig_source_x_1, '0', probSign, '0']
- [blocks_complex_to_real_0_0_0_0, '0', qtgui_time_sink_x_0_1, '1']
- [blocks_complex_to_real_0_0_0_0_0, '0', qtgui_time_sink_x_0_1_0, '1']
- [blocks_complex_to_real_0_0_0_1, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_complex_to_real_0_1_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_complex_to_real_0_1_0_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_complex_to_real_0_1_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_copy_0_0, '0', blocks_file_sink_0, '0']
- [blocks_float_to_complex_0_0, '0', epy_block_0_2, '0']
- [blocks_selector_0, '0', blocks_stream_demux_0, '0']
- [blocks_selector_0, '1', blocks_stream_demux_0_0, '0']
- [blocks_stream_demux_0, '0', epy_block_0_0_0_0, '0']
- [blocks_stream_demux_0, '1', epy_block_0_0_0_0, '1']
- [blocks_stream_demux_0_0, '0', epy_block_0_3_0_1, '0']
- [blocks_stream_demux_0_0, '1', epy_block_0_3_0_1, '1']
- [blocks_stream_mux_0, '0', blocks_copy_0_0, '0']
- [blocks_stream_mux_0_0, '0', blocks_selector_0, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_float_to_complex_0_0, '0']
- [epy_block_0, '0', blocks_stream_mux_0, '0']
- [epy_block_0, '0', pwr, '0']
- [epy_block_0, '1', ang, '0']
- [epy_block_0, '1', blocks_stream_mux_0, '1']
- [epy_block_0_0_0, '0', qtgui_compass_0, '0']
- [epy_block_0_0_0_0, '0', blocks_complex_to_real_0_1_0, '0']
- [epy_block_0_0_0_0, '0', epy_block_0_3_0_1_0, '0']
- [epy_block_0_0_0_0, '1', blocks_complex_to_real_0_0_0_0, '0']
- [epy_block_0_0_0_0, '1', epy_block_0_3_0_1_0, '1']
- [epy_block_0_0_0_0, '2', qtgui_number_sink_0_0_0_0, '0']
- [epy_block_0_0_0_0, phase_diff, epy_block_0_3_0_1, phase_diff]
- [epy_block_0_0_0_0, phase_diff, epy_block_0_3_0_1_0, phase_diff]
- [epy_block_0_2, '0', epy_block_0_3_0_0, '0']
- [epy_block_0_2, '0', epy_block_0_3_0_0, '1']
- [epy_block_0_3_0_0, '0', epy_block_1, '0']
- [epy_block_0_3_0_0, '1', epy_block_1, '1']
- [epy_block_0_3_0_1, '0', blocks_complex_to_real_0_1_1, '0']
- [epy_block_0_3_0_1, '0', epy_block_0_0_0, '0']
- [epy_block_0_3_0_1, '1', blocks_complex_to_real_0_0_0_1, '0']
- [epy_block_0_3_0_1, '1', epy_block_0_0_0, '1']
- [epy_block_0_3_0_1_0, '0', blocks_complex_to_real_0_1_0_0, '0']
- [epy_block_0_3_0_1_0, '1', blocks_complex_to_real_0_0_0_0_0, '0']
- [epy_block_1, '0', uhd_usrp_sink_0_0_0, '0']
- [epy_block_1, '1', uhd_usrp_sink_0_0_0, '1']
- [pdu_pdu_to_stream_x_0_0, '0', blocks_uchar_to_float_0_0, '0']
- [pdu_random_pdu_0_0_0, pdus, pdu_pdu_to_stream_x_0_0, pdus]
- [qtgui_edit_box_msg_0_0, msg, pdu_random_pdu_0_0_0, generate]
- [qtgui_edit_box_msg_0_0_0, msg, zeromq_push_msg_sink_0, in]
- [qtgui_edit_box_msg_0_0_0_0, msg, zeromq_push_msg_sink_0, in]
- [uhd_usrp_source_0, '0', blocks_stream_mux_0_0, '0']
- [uhd_usrp_source_0, '1', blocks_stream_mux_0_0, '1']
- [zeromq_pull_source_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
