options:
  parameters:
    generate_options: no_gui
    id: tx_rx_lora_USRP
    output_language: python
    realtime_scheduling: '1'
    title: Not titled yet
  states: {}

blocks:
- name: CR
  id: variable
  parameters:
    value: '4'
  states: {}
- name: H_est
  id: variable
  parameters:
    value: '[[h1_est,h2_est]]'
  states: {}
- name: SF
  id: variable
  parameters:
    value: '9'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: int(125e3)
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: int(868e6)
  states: {}
- name: const_multiply
  id: variable
  parameters:
    value: '1'
  states: {}
- name: corr_threshold
  id: variable
  parameters:
    value: int(8e3)
  states: {state: disabled}
- name: gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: h1_est
  id: variable
  parameters:
    value: '9'
  states: {}
- name: h2_est
  id: variable
  parameters:
    value: '9'
  states: {}
- name: os_factor
  id: variable
  parameters:
    value: '1'
  states: {}
- name: padding
  id: variable
  parameters:
    value: '100'
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: '18'
  states: {}
- name: payload_nitems
  id: variable
  parameters:
    value: int(payload_nsymb*pow(2,SF))
  states: {}
- name: payload_nsymb
  id: variable
  parameters:
    value: int((payload_len/SF)*(CR+4))
  states: {}
- name: preamble_len
  id: variable
  parameters:
    value: '6'
  states: {}
- name: preamble_nitems
  id: variable
  parameters:
    value: round(pow(2,SF)*(preamble_len+2.25))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bandwidth
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '0.1'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: lora_rx
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: lora_tx
    type: complex
  states: {}
- name: blocks_file_sink_0_1_0
  id: blocks_file_sink
  parameters:
    file: lora_rx_payload
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_1_0_0
  id: blocks_file_sink
  parameters:
    file: lora_rx_crop
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_2
  id: blocks_file_sink
  parameters:
    file: lora_rx
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_2_0_0
  id: blocks_file_sink
  parameters:
    file: lora_tx_payload
    type: complex
    vlen: payload_nitems
  states: {}
- name: blocks_file_sink_0_3
  id: blocks_file_sink
  parameters:
    file: lora_rx_crop
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_3_0_0_0
  id: blocks_file_sink
  parameters:
    file: dumpIN
    type: byte
  states: {}
- name: blocks_file_sink_0_3_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: dumpOUT
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_3_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: dumpOUTsymb
    type: int
  states: {state: disabled}
- name: blocks_file_sink_0_3_0_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: dumpINsymb
    type: int
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: USRP_1
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: USRP_2
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("#t")
    period: '5000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1+0.1j
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_3
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_4
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (preamble_nitems+payload_nitems, preamble_nitems+payload_nitems)
    type: complex
  states: {state: disabled}
- name: blocks_stream_mux_0_0
  id: blocks_stream_mux
  parameters:
    lengths: (100000, preamble_nitems + payload_nitems)
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: pow(2,SF)*os_factor
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: payload_nitems
    type: complex
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_align_1
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: '"payload_begin"'
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_align_1_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: '"threshold_exceeded"'
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_align_1_0_1
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: '"threshold_exceeded"'
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_align_1_1
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: '"preamble_begin"'
    type: complex
  states: {state: disabled}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: h1_est
    target: h1_est
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: (1, 2, 3, 4, 5, 6, 7, 8, 9, 8, 7, 6, 5, 4, 3, 2, 1, 2, 5 ,6)
  states: {state: disabled}
- name: blocks_vector_source_x_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[0]*100000'
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: payload_nitems+preamble_nitems+padding
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: pow(2,SF)
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: '0'
    seed: '0'
    taps: 1+4j
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    CR: CR
    SF: SF
    _source_code: |-
      """
      Deinterleaving block
      Inverse of interleaving block.
      Reference : "Towards an SDR implementation of LoRa..." 2020 A.Marquet, N.Montavont, G.Papadopoulos)

      INPUT:
          - in_sig[0]: CR int32 input sequence
      OUTPUT:
          - out_sig[0]: SF bytes output sequence (4+CR useful bits per byte)
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class Deinterleaver(gr.basic_block):
          def __init__(self, SF=9, CR=2):
              gr.basic_block.__init__(self,
                  name="LoRa Deinterleaver",
                  in_sig=[np.uint32],
                  out_sig=[np.uint8])
              self.SF = SF
              self.CR = CR
              self.set_tag_propagation_policy(gr.TPP_DONT)

          def forecast(self, noutput_items, ninputs) :
              #ninput_items_required[i] is the number of items that will be consumed on input port i
              ninput_items_required = [self.CR+4]*ninputs # we need CR+4 items to produce anything
              return ninput_items_required

          def general_work(self, input_items, output_items):
              
              tags = self.get_tags_in_window(0, 0, len(input_items[0]))
              for tag in tags:
                  key = pmt.to_python(tag.key) # convert from PMT to python string
                  value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was
                  # print('key:', key)
                  # print('value:', value, type(value))
                  # print('')
                  self.add_item_tag(0, self.nitems_written(0), tag.key, tag.value)

              if(len(input_items[0]) >= self.CR+4) :  # if we have enough items to process

                  in0 = input_items[0][:self.CR+4]    # input buffer reference

                  # formatting the input buffer
                  input_matrix = np.zeros((self.CR+4, self.SF), dtype=np.uint8)
                  for i in range(len(in0)):
                      bits_crop = [int(x) for x in bin(in0[i])[2:]]                               # convert to binary         
                      input_matrix[i][:] = ([0]*(self.SF-len(bits_crop)) + bits_crop)[-(self.SF):]    # crop to SF bits

                  # deinterleaving
                  output_matrix = np.zeros((self.SF, self.CR+4), dtype=np.uint8)
                  for i in range(0,(self.SF)) :
                      for j in range(0,(self.CR+4)) :
                          idi=self.CR+4-1-j
                          idj=(self.SF-1-i+(self.CR+4)-1-j)%self.SF
                          output_matrix[i][j]=input_matrix[idi][idj]

                  # to uint32
                  output_items[0][0:(self.SF)] = output_matrix.dot(1 << np.arange(output_matrix.shape[-1] - 1, -1, -1))

                  # # debug
                  # print("\n--- GENERAL WORK : DEINTERLEAVER ---")
                  # print("in0 :")
                  # print(in0)
                  # print("len(in0) (should be CR+4): ")
                  # print(len(in0))
                  # print("input_matrix (CR+4 x SF):")
                  # print(input_matrix)
                  # print("output_matrix (SF x CR+4 ):")
                  # print(output_matrix)
                  # print("output_items[0] = ")
                  # print(output_items[0][0:(self.SF)])
                  # print("return len(output_items[0]) (should be CR+4): ")
                  # print(len(output_items[0]))

                  self.consume(0, self.CR+4)  # consume inputs (should be CR+4)
                  return self.SF              # return produced outputs (should be SF)

              else :
                  return 0
  states: {state: disabled}
- name: epy_block_0_1_0_0
  id: epy_block
  parameters:
    CR: CR
    SF: SF
    _source_code: "\"\"\"\nInterleaving block\nScrambles bits together to fight error bursts.\nReference : \"Towards an SDR implementation of LoRa...\" 2020 A.Marquet, N.Montavont, G.Papadopoulos)\n\nINPUT:\n    - in_sig[0]: SF bytes input sequence (4+CR useful bits per byte)\nOUTPUT:\n    - out_sig[0]: CR int32 output sequence\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time \n\nclass Interleaver(gr.basic_block):\n    def __init__(self, SF=9, CR=4):\n        gr.basic_block.__init__(self,\n            name=\"LoRa Interleaver\",\n            in_sig=[np.uint8],\n            out_sig=[np.uint32])\n        self.SF = SF\n        self.CR = CR\n\n    def forecast(self, noutput_items, ninputs) :\n        #ninput_items_required[i] is the number of items that will be consumed on input port i\n        ninput_items_required = [self.SF]*ninputs   # we need SF items to produce anything\n        return ninput_items_required\n\n    def general_work(self, input_items, output_items):\n        if(len(input_items[0]) >= self.SF and len(output_items[0]) >= self.CR+4) :    # if we have enough items to process\n            in0 = input_items[0][:self.SF]  # input buffer reference\n\n            # formatting the input buffer\n            input_matrix = np.zeros((self.SF, self.CR+4), dtype=np.uint8)\n            for i in range(len(in0)):\n                bits_crop = [int(x) for x in bin(in0[i])[2:]]                                       # convert to binary  \n                input_matrix[i][:] = ([0]*(self.CR+4-len(bits_crop)) + bits_crop)[-(self.CR+4):]    # crop to 4+CR bits\n\n            # interleaving\n            output_matrix = np.zeros((self.CR+4, self.SF), dtype=np.uint8)\n            for i in range(0,(self.CR+4)) :\n                for j in range(0,(self.SF)) :\n                    idi=self.SF-1-(j-i)%self.SF\n                    idj=self.CR+4-1-i\n                    output_matrix[i][j]=input_matrix[idi][idj]\n            \n            # # debug\n            # print(\"\\n--- GENERAL WORK : INTERLEAVER ---\")\n            # print(\"in0 :\")\n            # print(in0)\n            # print(\"len(in0) (should be SF): \")\n            # print(len(in0))\n            # print(\"input_matrix (SF x CR+4):\")\n            # print(input_matrix)\n            # print(\"output_matrix (CR+4 x SF):\")\n            # print(output_matrix)\n            # print(\"output_items[0] = \")\n            # print(output_items[0])\n\n\n            # to uint32\n            output_items[0][0:(self.CR+4)] = output_matrix.dot(1 << np.arange(output_matrix.shape[-1] - 1, -1, -1))\n\n            self.consume(0, self.SF)    # consume inputs (should be SF)\n            return self.CR+4            # return produced outputs (should be CR+4)\n\n        else :\n            return 0\n\n\n\n"
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    CR: CR
    _source_code: |-
      """
      Hamming decoding block
      Forward Error Correction decoding block.
      Reference : "MIT EECS II : http://web.mit.edu/6.02/www/f2012/handouts/L05_slides.pdf"

      INPUT:
          - in_sig[0]: binary input sequence (4+CR useful bits per byte)
      OUTPUT:
          - out_sig[0]: binary output sequence (4 useful bits per byte)
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class HammingRx(gr.sync_block):
          def __init__(self, CR = 2, payload_len = 16):
              gr.sync_block.__init__(
                  self,
                  name='LoRa Hamming Rx',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.CR = CR
              self.payload_len = payload_len
              self.items_counter = 0 # debug
              self.success_counter = 0

          def decode(self, input_vect, CR_loc) : 

              output=input_vect
              success_state = 0 # 3 if 1 error detected, 2 if 2 errors detected, 1 if 1 error corrected,  0 if no error

              if CR_loc == 1: # CR = 1, no error correction
                  
                  syndrome = input_vect[0] ^ input_vect[1] ^ input_vect[2] ^ input_vect[3] ^ input_vect[4]
                  success_state = 0 if syndrome == 0 else 3
                  output = input_vect

              if CR_loc == 2: # CR = 2, no error correction
                  
                  syndrome = np.zeros((2,1), dtype=np.uint8)
                  syndrome[0] = input_vect[0] ^ input_vect[1] ^ input_vect[2] ^ input_vect[5]
                  syndrome[1] = input_vect[1] ^ input_vect[2] ^ input_vect[3] ^ input_vect[4]
                  success_state = 0 if syndrome.all() == 0 else 3
                  output = input_vect

              if CR_loc == 3: # CR = 3, 1 error correction is possible
                  n = 4+CR_loc
                  k = 4

                  # compute syndrome of input_vect
                  Q = np.array([[0,1,1], [1,1,0], [1,1,1], [1,0,1]], np.uint8)
                  Id = np.identity(n-k, dtype=np.uint8)
                  H = np.concatenate((Q.transpose(), Id),axis=1)
                  syndrome = np.dot(input_vect[:], H.transpose())%2

                  # compute syndromes lookup table
                  tmp = np.zeros((1,n-k+4), dtype=np.uint8)
                  tmp2 = np.identity(n-k+4, dtype=np.uint8)
                  E = np.concatenate((tmp, tmp2),axis=0)
                  S = np.dot(E,H.transpose())%2   
                  for j in range(S.shape[0]):             # iterate through the syndromes lookup table
                      if np.array_equal(S[j],syndrome):   # if found, correct the input_vect
                          output = input_vect ^ E[j][:]
                          success_state = 1               # 1 error corrected

              if CR_loc == 4: # CR = 4, 1 error correction is possible, 2 error detection is possible
                  
                  n = 4+CR_loc
                  k = 4

                  # compute syndrome of input_vect
                  Q = np.array([[0,1,1,1], [1,1,0,1], [1,1,1,0], [1,0,1,1]], np.uint8)
                  Id = np.identity(n-k, dtype=np.uint8)
                  H = np.concatenate((Q.transpose(), Id),axis=1)
                  syndrome = np.dot(input_vect[:], H.transpose())%2


                  if np.array_equal(syndrome,np.array([0,0,0,0])):    # if no error, return input_vect
                      output = input_vect

                  else :
                      # compute parity bit
                      parity = input_vect[0] ^ input_vect[1] ^ input_vect[2] ^ input_vect[3] ^ input_vect[4] ^ input_vect[5] ^ input_vect[6] ^ input_vect[7]
                      
                      if parity : # 1 error correctable
                          output, success_state = self.decode(input_vect[:][0:7], 3) # correct the first 7 bits by sending them to the decoding function
              
                      else :  # 2 errors detected
                          success_state = 2
                      
              return output[:][0:4], success_state # return the first 4 bits (data bits) and success_state (integer)

          def work(self, input_items, output_items):

              in0 = input_items[0]    # input buffer reference
              out = output_items[0]   # output buffer reference
          
              output_matrix = np.zeros((len(in0), 4), dtype=np.uint8)
              input_matrix = np.zeros((len(in0), 4+self.CR), dtype=np.uint8)
              success_states = np.zeros((len(in0), 1), dtype=np.uint8)

              for i in range(len(in0)):
                  bits_crop = [int(x) for x in bin(in0[i])[2:]]                                       # convert to binary
                  input_matrix[i][:] = ([0]*(self.CR+4-len(bits_crop)) + bits_crop)[-(self.CR+4):]    # crop to 4+CR bits
                  output_matrix[i][:], success_states[i] = self.decode(input_matrix[i][:],self.CR)    # send to decoding function
              
              arr,trash = np.histogram(success_states, bins = [-1, 0.5, 1.5, 2.5, 3.5])

              self.items_counter += len(in0)
              self.success_counter += arr[0]
              if self.items_counter >= self.payload_len:
                  print("[RX] Hamming : symbols without errors = %d / %d" % (self.success_counter, self.payload_len))
                  self.success_counter = 0
                  self.items_counter = 0


              # convert output matrix to uint8
              out[:] = output_matrix.dot(1 << np.arange(output_matrix.shape[-1] - 1, -1, -1))

              # display success states
              # print("Success states:")
              # print(success_states)
              # print("[RX] Hamming : n1_detected = %d, n2_detected = %d, n1_corrrected = %d, n0 = %d" % (arr[3], arr[2], arr[1], arr[0]))
              # print("[RX] Hamming : n0 = ", arr[0])
              # tags = self.get_tags_in_window(0, 0, len(input_items[0]))
              # for tag in tags:
              #     key = pmt.to_python(tag.key) # convert from PMT to python string
              #     value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was
              #     print('key:', key)
              #     print('value:', value, type(value))
              #     print('')
              # # debug
              # print("\n--- GENERAL WORK : HAMMING_DEC ---")
              # print("in0 :")
              # print(in0)
              # print("input_matrix :")
              # print(input_matrix)
              # print("output_matrix :")
              # print(output_matrix)
              # print("out :")
              # print(out)
              # print("--- HAMMING_DEC END---")

              return len(output_items[0])
    payload_len: payload_len
  states: {state: disabled}
- name: epy_block_10
  id: epy_block
  parameters:
    SF: '9'
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import math
      import pmt

      def modulate_vect(SF, id, os_factor, sign) :
          M  = pow(2,SF)
          ka = np.arange(0,M)
          fact1 = np.exp(1j*sign*math.pi*(pow(ka,2))/M)
          chirp = np.zeros((len(id),M*os_factor), dtype=np.complex64)
          for i in range(len(id)) :
              chirp[i] = fact1*np.exp(2j*math.pi*(id[i]/M)*ka)
          return chirp

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, preamble_len = 6, SF = 9):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='LoRa SNR estimator',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.preamble_len = preamble_len
              self.SF = SF

          def work(self, input_items, output_items):

              preamble_up = np.reshape(modulate_vect(self.SF, [0]*self.preamble_len, 1, 1), -1)      # generate preamble_len upchirps
              preamble_down = np.reshape(np.conjugate(modulate_vect(self.SF, [0]*3, 1, 1)), -1)      # generate 3 downchirps
              preamble = np.concatenate((preamble_up, preamble_down[0:int(2.25*pow(2,self.SF))])) # concatenate preamble_up and preamble_down[0:2.25*M]

              


              output_items[0][:] = input_items[0]
              return len(output_items[0])
    preamble_len: '6'
  states: {state: disabled}
- name: epy_block_11
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import matplotlib.pyplot as plt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              in0 = input_items[0][:512*2]
              output_items[0][:len(in0)] = in0

              plt.specgram(in0, NFFT=64, Fs=32, noverlap=8)
              plt.show()


              return len(in0)
  states: {state: disabled}
- name: epy_block_12
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import math
      import matplotlib.pyplot as plt


      def modulate_vect(SF, id, os_factor, sign) :
          M  = pow(2,SF)
          ka = np.arange(0,M)
          fact1 = np.exp(1j*sign*math.pi*(pow(ka,2))/M)
          chirp = np.zeros((len(id),M*os_factor), dtype=np.complex64)
          for i in range(len(id)) :
              chirp[i] = fact1*np.exp(2j*math.pi*(id[i]/M)*ka)
          return chirp

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Channel estimator',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.SF = 9
              self.preamble_len = 6
              preamble_up = np.reshape(modulate_vect(self.SF, [0]*self.preamble_len, 1, 1), -1)      # generate preamble_len upchirps
              preamble_down = np.reshape(np.conjugate(modulate_vect(self.SF, [0]*3, 1, 1)), -1)      # generate 3 downchirps
              self.preamble = np.concatenate((preamble_up, preamble_down[0:int(2.25*pow(2,self.SF))])) # concatenate preamble_up and preamble_down[0:2.25*M]
              self.set_output_multiple(len(self.preamble))

          def work(self, input_items, output_items):

              in0 = input_items[0][:len(self.preamble)]

              h_est = in0.T*self.preamble# https://www.youtube.com/watch?v=XCe0xanaPFo
              print("[RX] Channel : h^est =",h_est[0])
              
              fig, axs = plt.subplots(4)
              axs[0].specgram(in0, NFFT=64, Fs=32, noverlap=8)
              axs[1].specgram(self.preamble, NFFT=64, Fs=32, noverlap=8)
              axs[2].plot(in0)
              axs[3].plot(self.preamble)
              # axs[4].plot(np.arange(0,len(h)),np.real(h),np.arange(0,len(h)), np.imag(h))
              # axs[4].set_ylim([-1,1])
              plt.show()

              
              output_items[0][:len(in0)] = in0
              return len(in0)
  states: {state: disabled}
- name: epy_block_13
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt



      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Estimation + Precoding',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64, np.complex64]
              )
              self.message_port_register_in(pmt.intern("h1_est"))
              self.message_port_register_in(pmt.intern("h2_est"))

              self.h1_est = []
              self.h2_est = []
              self.state = 'est_h1'
              self.set_msg_handler(pmt.intern("h1_est"), self.handle_msg_h1)
              self.set_msg_handler(pmt.intern("h2_est"), self.handle_msg_h2)

          def handle_msg_h1(self,msg) :
              print("message received h1")
              self.h1_est.append(pmt.to_complex(msg))
              self.state = 'est_h2'

          def handle_msg_h2(self,msg) :
              print("message received h2")
              self.h1_est.append(pmt.to_complex(msg))
              self.state = 'est_h1'
          

          def work(self, input_items, output_items):
              
              tags = self.get_tags_in_window(0, 0, len(input_items[0]))
              for tag in tags:
                  key = pmt.to_python(tag.key) # convert from PMT to python string
                  value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was
                  if key == 'tx_sob':
                      pass
              
              if self.state == 'est_h1' :
                  output_items[0][:] = input_items[0] * 1
                  output_items[1][:] = input_items[0] * 0
                  return len(output_items[0])

              if self.state == 'est_h2' :
                  output_items[0][:] = input_items[0] * 0
                  output_items[1][:] = input_items[0] * 1
                  return len(output_items[0])
  states: {}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Whitening block
      Whiten input sequence to remove the frequency and time correlations in it.

      INPUT:
          - in_sig[0]: binary input sequence (4 useful bits per byte)
      OUTPUT:
          - out_sig[0]: whitened binary sequence
      """

      import numpy as np
      from gnuradio import gr
      import time
      import pmt

      whitening_seq =(0xFF, 0xFE, 0xFC, 0xF8, 0xF0, 0xE1, 0xC2, 0x85, 0x0B, 0x17, 0x2F, 0x5E, 0xBC, 0x78, 0xF1, 0xE3,
                      0xC6, 0x8D, 0x1A, 0x34, 0x68, 0xD0, 0xA0, 0x40, 0x80, 0x01, 0x02, 0x04, 0x08, 0x11, 0x23, 0x47,
                      0x8E, 0x1C, 0x38, 0x71, 0xE2, 0xC4, 0x89, 0x12, 0x25, 0x4B, 0x97, 0x2E, 0x5C, 0xB8, 0x70, 0xE0,
                      0xC0, 0x81, 0x03, 0x06, 0x0C, 0x19, 0x32, 0x64, 0xC9, 0x92, 0x24, 0x49, 0x93, 0x26, 0x4D, 0x9B,
                      0x37, 0x6E, 0xDC, 0xB9, 0x72, 0xE4, 0xC8, 0x90, 0x20, 0x41, 0x82, 0x05, 0x0A, 0x15, 0x2B, 0x56,
                      0xAD, 0x5B, 0xB6, 0x6D, 0xDA, 0xB5, 0x6B, 0xD6, 0xAC, 0x59, 0xB2, 0x65, 0xCB, 0x96, 0x2C, 0x58,
                      0xB0, 0x61, 0xC3, 0x87, 0x0F, 0x1F, 0x3E, 0x7D, 0xFB, 0xF6, 0xED, 0xDB, 0xB7, 0x6F, 0xDE, 0xBD,
                      0x7A, 0xF5, 0xEB, 0xD7, 0xAE, 0x5D, 0xBA, 0x74, 0xE8, 0xD1, 0xA2, 0x44, 0x88, 0x10, 0x21, 0x43,
                      0x86, 0x0D, 0x1B, 0x36, 0x6C, 0xD8, 0xB1, 0x63, 0xC7, 0x8F, 0x1E, 0x3C, 0x79, 0xF3, 0xE7, 0xCE,
                      0x9C, 0x39, 0x73, 0xE6, 0xCC, 0x98, 0x31, 0x62, 0xC5, 0x8B, 0x16, 0x2D, 0x5A, 0xB4, 0x69, 0xD2,
                      0xA4, 0x48, 0x91, 0x22, 0x45, 0x8A, 0x14, 0x29, 0x52, 0xA5, 0x4A, 0x95, 0x2A, 0x54, 0xA9, 0x53,
                      0xA7, 0x4E, 0x9D, 0x3B, 0x77, 0xEE, 0xDD, 0xBB, 0x76, 0xEC, 0xD9, 0xB3, 0x67, 0xCF, 0x9E, 0x3D,
                      0x7B, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFA, 0xF4, 0xE9, 0xD3, 0xA6, 0x4C, 0x99, 0x33, 0x66,
                      0xCD, 0x9A, 0x35, 0x6A, 0xD4, 0xA8, 0x51, 0xA3, 0x46, 0x8C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07,
                      0x0E, 0x1D, 0x3A, 0x75, 0xEA, 0xD5, 0xAA, 0x55, 0xAB, 0x57, 0xAF, 0x5F, 0xBE, 0x7C, 0xF9, 0xF2,
                      0xE5, 0xCA, 0x94, 0x28, 0x50, 0xA1, 0x42, 0x84, 0x09, 0x13, 0x27, 0x4F, 0x9F, 0x3F, 0x7F)

      class Whitening(gr.sync_block):
          def __init__(self, reset_key="tx_sob"):
              gr.sync_block.__init__(
                  self,
                  name='LoRa Whitening',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.table_idx = 0 # index of the whitening table cell to be used for whitening
              self.frame_counter = 0 # frame number
              
          def work(self, input_items, output_items):
              
              tags = self.get_tags_in_window(0, 0, len(input_items[0]))
              for tag in tags:
                  key = pmt.to_python(tag.key) # convert from PMT to python string
                  value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was
                  
                  if key == 'tx_sob':
                      self.frame_counter += 1
                      # print("\n[TX] Whitening  : frame sent, number : ", self.frame_counter)
                      self.table_idx = 0

              in0 = input_items[0]    # input buffer reference
              out = output_items[0]   # output buffer reference

              input_matrix = np.zeros((len(in0), 4), dtype=np.uint8)
              for i in range(len(in0)):
                  bits_crop = [int(x) for x in bin(in0[i])[2:]]                       # convert to binary
                  input_matrix[i][:] = ([0]*(4-len(bits_crop)) + bits_crop)[-(4):]    # crop to 4 useful bits
                  out[i] = in0[i] ^ whitening_seq[self.table_idx] # whiten (XOR) the input vector
                  self.table_idx += 1                         # increment table index
                  if(self.table_idx == len(whitening_seq)):   # if table index is out of bounds, reset it
                      self.table_idx = 0
         


              # # debug
              # print("\n--- GENERAL WORK : WHITENING ---")
              # print("in0 :")
              # print(in0)
              # print("input_matrix :")
              # print(input_matrix)
              # print("out :")
              # print(out)
              # print("return len(out): ")
              # print(len(out))
              # print("--- WHITENING END---")

              return len(out)
    reset_key: '"tx_sob"'
  states: {}
- name: epy_block_1_1
  id: epy_block
  parameters:
    CR: CR
    _source_code: |
      """
      Hamming encoding block
      Forward Error Correction encoding block.
      Reference : "MIT EECS II : http://web.mit.edu/6.02/www/f2012/handouts/L05_slides.pdf"

      INPUT:
          - in_sig[0]: binary input sequence (4 useful bits per byte)
      OUTPUT:
          - out_sig[0]: binary output sequence (4+CR useful bits per byte)
      """

      import numpy as np
      from gnuradio import gr


      class HammingTx(gr.sync_block):
          def __init__(self, CR = 4):
              gr.sync_block.__init__(
                  self,
                  name='LoRa Hamming Tx',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.CR = CR

          def work(self, input_items, output_items):
              
              in0 = input_items[0]    # input buffer reference
              out = output_items[0]   # output buffer reference
          
              output_matrix = np.zeros((len(in0), 4+self.CR), dtype=np.uint8)
              input_matrix = np.zeros((len(in0), 4), dtype=np.uint8)

              # Hamming encoding (iterate over matrix lines and encode each)
              for i in range(len(in0)):
                  bits_crop = [int(x) for x in bin(in0[i])[2:]]                       # convert to binary    
                  input_matrix[i][:] = ([0]*(4-len(bits_crop)) + bits_crop)[-(4):]    # crop to 4 bits

                  if self.CR == 1: # CR = 1, add one parity bit
                      p0 = input_matrix[i][0] ^ input_matrix[i][1] ^ input_matrix[i][2] ^ input_matrix[i][3]
                      output_matrix[i] = np.asarray([input_matrix[i][0], input_matrix[i][1], input_matrix[i][2], input_matrix[i][3], p0], dtype=np.uint8)

                  if self.CR == 2: # CR = 2, add two parity bits
                      p0 = input_matrix[i][0] ^ input_matrix[i][1] ^ input_matrix[i][2]
                      p1 = input_matrix[i][1] ^ input_matrix[i][2] ^ input_matrix[i][3]
                      output_matrix[i] = np.asarray([input_matrix[i][0], input_matrix[i][1], input_matrix[i][2], input_matrix[i][3], p1, p0], dtype=np.uint8)

                  if self.CR == 3: # CR = 3, add three parity bits (Hamming(7,4))
                      Q = np.array([[0,1,1,1], [1,1,0,1], [1,1,1,0], [1,0,1,1]], np.uint8) 
                      Id = np.identity(4, dtype=np.uint8)
                      G = np.concatenate((Id, Q),axis=1)  # generator matrix
                      output_matrix[i] = (np.dot(input_matrix[i],G)%2)[0:4+self.CR]

                  if self.CR == 4: # CR = 4, add four parity bits (Hamming(8,4))
                      Q = np.array([[0,1,1,1], [1,1,0,1], [1,1,1,0], [1,0,1,1]], np.uint8)
                      Id = np.identity(4, dtype=np.uint8)
                      G = np.concatenate((Id, Q),axis=1)  # generator matrix
                      output_matrix[i] = (np.dot(input_matrix[i],G)%2)

              # binary to decimal conversion
              out[:] = output_matrix.dot(1 << np.arange(output_matrix.shape[-1] - 1, -1, -1))

              # #debug
              # print("\n--- GENERAL WORK : HAMMING_ENC ---")
              # print("in0 :")
              # print(in0)
              # print("input_matrix :")
              # print(input_matrix)
              # print("output_matrix :")
              # print(output_matrix)
              # print("out :")
              # print(out)
              # print("--- HAMMING_ENC END---")

              return len(output_items[0])
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      Dewhitening block
      Remove white noise from the signal

      INPUT:
          - in_sig[0]: whitened binary input sequence
      OUTPUT:
          - out_sig[0]: output binary sequence with white noise removed
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      whitening_seq =(0xFF, 0xFE, 0xFC, 0xF8, 0xF0, 0xE1, 0xC2, 0x85, 0x0B, 0x17, 0x2F, 0x5E, 0xBC, 0x78, 0xF1, 0xE3,
                      0xC6, 0x8D, 0x1A, 0x34, 0x68, 0xD0, 0xA0, 0x40, 0x80, 0x01, 0x02, 0x04, 0x08, 0x11, 0x23, 0x47,
                      0x8E, 0x1C, 0x38, 0x71, 0xE2, 0xC4, 0x89, 0x12, 0x25, 0x4B, 0x97, 0x2E, 0x5C, 0xB8, 0x70, 0xE0,
                      0xC0, 0x81, 0x03, 0x06, 0x0C, 0x19, 0x32, 0x64, 0xC9, 0x92, 0x24, 0x49, 0x93, 0x26, 0x4D, 0x9B,
                      0x37, 0x6E, 0xDC, 0xB9, 0x72, 0xE4, 0xC8, 0x90, 0x20, 0x41, 0x82, 0x05, 0x0A, 0x15, 0x2B, 0x56,
                      0xAD, 0x5B, 0xB6, 0x6D, 0xDA, 0xB5, 0x6B, 0xD6, 0xAC, 0x59, 0xB2, 0x65, 0xCB, 0x96, 0x2C, 0x58,
                      0xB0, 0x61, 0xC3, 0x87, 0x0F, 0x1F, 0x3E, 0x7D, 0xFB, 0xF6, 0xED, 0xDB, 0xB7, 0x6F, 0xDE, 0xBD,
                      0x7A, 0xF5, 0xEB, 0xD7, 0xAE, 0x5D, 0xBA, 0x74, 0xE8, 0xD1, 0xA2, 0x44, 0x88, 0x10, 0x21, 0x43,
                      0x86, 0x0D, 0x1B, 0x36, 0x6C, 0xD8, 0xB1, 0x63, 0xC7, 0x8F, 0x1E, 0x3C, 0x79, 0xF3, 0xE7, 0xCE,
                      0x9C, 0x39, 0x73, 0xE6, 0xCC, 0x98, 0x31, 0x62, 0xC5, 0x8B, 0x16, 0x2D, 0x5A, 0xB4, 0x69, 0xD2,
                      0xA4, 0x48, 0x91, 0x22, 0x45, 0x8A, 0x14, 0x29, 0x52, 0xA5, 0x4A, 0x95, 0x2A, 0x54, 0xA9, 0x53,
                      0xA7, 0x4E, 0x9D, 0x3B, 0x77, 0xEE, 0xDD, 0xBB, 0x76, 0xEC, 0xD9, 0xB3, 0x67, 0xCF, 0x9E, 0x3D,
                      0x7B, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFA, 0xF4, 0xE9, 0xD3, 0xA6, 0x4C, 0x99, 0x33, 0x66,
                      0xCD, 0x9A, 0x35, 0x6A, 0xD4, 0xA8, 0x51, 0xA3, 0x46, 0x8C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07,
                      0x0E, 0x1D, 0x3A, 0x75, 0xEA, 0xD5, 0xAA, 0x55, 0xAB, 0x57, 0xAF, 0x5F, 0xBE, 0x7C, 0xF9, 0xF2,
                      0xE5, 0xCA, 0x94, 0x28, 0x50, 0xA1, 0x42, 0x84, 0x09, 0x13, 0x27, 0x4F, 0x9F, 0x3F, 0x7F)

      # # debug
      # whitening_seq_debug = 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF
      # whitening_seq = whitening_seq_debug

      class LoraDewhitening(gr.sync_block):
          def __init__(self, reset_key = "payload_begin"):
              gr.sync_block.__init__(
                  self,
                  name='LoRa Dewhitening',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.table_idx = 0 # index of the whitening table cell to be used for whitening
              
          def work(self, input_items, output_items):
              
              tags = self.get_tags_in_window(0, 0, len(input_items[0]))
              for tag in tags:
                  key = pmt.to_python(tag.key) # convert from PMT to python string
                  value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was
                  
                  if key == 'payload_begin':
                      self.table_idx = 0

                  # # debug
                  # print('key:', key)
                  # print('value:', value, type(value))
                  # print('')


              in0 = input_items[0]    # input buffer
              out = output_items[0]   # output buffer

              input_matrix = np.zeros((len(in0), 4), dtype=np.uint8)
              for i in range(len(in0)):
                  bits_crop = [int(x) for x in bin(in0[i])[2:]]                       # convert to binary
                  input_matrix[i][:] = ([0]*(4-len(bits_crop)) + bits_crop)[-(4):]    # crop to 4 useful bits
                  
                  out_temp = in0[i] ^ whitening_seq[self.table_idx]   # dewhitening

                  bits_out_temp_crop = [int(x) for x in bin(out_temp)[2:]]                                # convert to binary
                  bits_out_temp_crop_norm = ([0]*(4-len(bits_out_temp_crop)) + bits_out_temp_crop)[-(4):] # crop to 4 useful bits

                  # binary to decimal conversion
                  output_items[0][i] = np.array(bits_out_temp_crop_norm).dot(1 << np.arange(np.array(bits_out_temp_crop_norm).shape[-1] - 1, -1, -1))

                  self.table_idx += 1                         # increment table index
                  if(self.table_idx == len(whitening_seq)):   # if table index is out of bounds, reset it
                      self.table_idx = 0

              # # debug
              # print("\n--- GENERAL WORK : DEWHITENING ---")
              # print("in0 :")
              # print(in0)
              # print("input_matrix :")
              # print(input_matrix)
              # print("out :")
              # print(output_items[0][:])
              # print("return len(out): ")
              # print(len(output_items[0]))
              # print("--- DEWHITENING END---")
              
              return len(output_items[0])
    reset_key: '"payload_begin"'
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    SF: SF
    _source_code: |-
      """
      Preamble Generation Block:
      Reference : "Towards an SDR implementation of LoRa..." 2020 A.Marquet, N.Montavont, G.Papadopoulos)

      INPUT:
          - None
      OUTPUT:
          - out_sig[0]: IQ complex vector, length = M * os_factor * (preamble_len + 2.25)
      """

      import numpy as np
      from gnuradio import gr
      import math
      import time
      import pmt

      def modulate_vect(SF, id, os_factor, sign) :
          M  = pow(2,SF)
          ka = np.arange(0,M)
          fact1 = np.exp(1j*sign*math.pi*(pow(ka,2))/M)
          chirp = np.zeros((len(id),M*os_factor), dtype=np.complex64)
          for i in range(len(id)) :
              chirp[i] = fact1*np.exp(2j*math.pi*(id[i]/M)*ka)
          return chirp

      class PreambleGenerator(gr.sync_block):

          def __init__(self, SF = 9, preamble_len = 6):
              gr.sync_block.__init__(
                  self,
                  name='LoRa Preamble Generator',
                  in_sig=None,
                  out_sig=[(np.complex64,round(pow(2,SF)*(preamble_len+2.25)))]   # !!! will cause problem if os_factor > 1 !!! 
              )
              self.SF = SF
              self.preamble_len = preamble_len

          def work(self, input_items, output_items):
              # t = time.time()
              preamble_up = np.reshape(modulate_vect(self.SF, [0]*self.preamble_len, 1, 1), -1)      # generate preamble_len upchirps
              preamble_down = np.reshape(np.conjugate(modulate_vect(self.SF, [0]*3, 1, 1)), -1)      # generate 3 downchirps
              output_items[0][:] = np.concatenate((preamble_up, preamble_down[0:int(2.25*pow(2,self.SF))])) # concatenate preamble_up and preamble_down[0:2.25*M]
              # # TAGS
              # key = pmt.intern("tx_sob")
              # value = pmt.from_bool(True)
              # self.add_item_tag(0, # Write to output port 0
              #         self.nitems_written(0), # Index of the tag in absolute terms
              #         key, # Key of the tag
              #         value # Value of the tag
              # )
              return len(output_items[0])
    preamble_len: preamble_len
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    SF: '9'
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import math
      import matplotlib.pyplot as plt

      def modulate(SF, id, os_factor, sign) :
          M  = pow(2,SF)
          ka = np.arange(0,M)
          fact1 = np.exp(1j*sign*math.pi*(pow(ka,2))/M)
          chirp = fact1*np.exp(2j*math.pi*(id/M)*ka)
          return chirp

      def gamma(k) :
          # print("gamma , ", k)
          if k >= 0 and k < 256 :
              return k
          if k >= 256 and k < 512 :
              return k - 512

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, SF = 9):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Frequency correction',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.symbcounter = 0
              self.SF = SF
              self.f_up = 5555555
              self.f_down = 1693653

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              
              self.symbcounter += 1 
              M = pow(2,self.SF)
              freq_vect = np.arange(0,M)
              base_downchirp = modulate(self.SF, 0, 1, -1)
              base_upchirp = modulate(self.SF, 0, 1, 1)

              if self.symbcounter == 1 :
                  in0 = input_items[0][:512]
                  demod_signal = np.multiply(in0, base_downchirp)   # multiply every symbol with the downchirp
                  demod_signal_fft = np.fft.fft(demod_signal)                     # perform FFT on demodulated signal    
                  idx = np.argmax(np.abs(demod_signal_fft))                       # find the frequency index of the maximum value
                  self.f_up = round(round(freq_vect[idx]))               # convert the frequency index to symbol index
                  print("f_up = ", self.f_up)

              if self.symbcounter == 2 :
                  in0 = input_items[0][:512-(self.f_up)]
                  # in0 =  input_items[0][:512]

              if self.symbcounter == 8 :
                  in0 = input_items[0][:512]
                  demod_signal = np.multiply(in0, base_upchirp)   # multiply every symbol with the downchirp
                  demod_signal_fft = np.fft.fft(demod_signal)                     # perform FFT on demodulated signal    
                  idx = np.argmax(np.abs(demod_signal_fft))                       # find the frequency index of the maximum value
                  self.f_down = round(round(freq_vect[idx]))               # convert the frequency index to symbol index
                  print("f_down = ", self.f_down)
                  # print(gamma(65))
                  CFO = 1/2*gamma(np.mod(self.f_up + self.f_down, 512))
                  STO = np.mod(self.f_up - CFO, 512) 
                  print("STO = ", STO)
                  print("CFO = ", CFO)

                  CFO_test =(self.f_down+self.f_up)/2
                  STO_test =(self.f_down-self.f_up)/2+1
                  print("STO_test = ", STO_test)
                  print("CFO_test = ", CFO_test)

              if self.symbcounter > 2 and self.symbcounter < 8 :
                  in0 = input_items[0][:512]
                  # demod_signal = np.multiply(in0, base_downchirp)   # multiply every symbol with the downchirp
                  # demod_signal_fft = np.fft.fft(demod_signal)                     # perform FFT on demodulated signal    
                  # idx = np.argmax(np.abs(demod_signal_fft))                       # find the frequency index of the maximum value
                  # f_up = round(round(freq_vect[idx]))               # convert the frequency index to symbol index
                  # print("f_up = ", f_up )

              if self.symbcounter == 8 :
                  in0 = input_items[0][:128]
                  self.symbcounter = 0

              # # # debug
              # vect = np.arange(0,len(in0))
              # print(self.symbcounter)
              # print(len(in0))
              # # plt.plot(vect, np.real(in0))
              # plt.specgram(in0, NFFT=64, Fs=32, noverlap=8)
              # plt.show()

              output_items[0][:len(in0)] = in0 
              return len(in0)
  states: {state: disabled}
- name: epy_block_4_0
  id: epy_block
  parameters:
    SF: '9'
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import math
      import matplotlib.pyplot as plt

      def modulate(SF, id, os_factor, sign) :
          M  = pow(2,SF)
          ka = np.arange(0,M)
          fact1 = np.exp(1j*sign*math.pi*(pow(ka,2))/M)
          chirp = fact1*np.exp(2j*math.pi*(id/M)*ka)
          return chirp

      import numpy as np
      from gnuradio import gr
      import math
      import matplotlib.pyplot as plt


      def modulate_vect(SF, id, os_factor, sign) :
          M  = pow(2,SF)
          ka = np.arange(0,M)
          fact1 = np.exp(1j*sign*math.pi*(pow(ka,2))/M)
          chirp = np.zeros((len(id),M*os_factor), dtype=np.complex64)
          for i in range(len(id)) :
              chirp[i] = fact1*np.exp(2j*math.pi*(id[i]/M)*ka)
          return chirp

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, SF = 9,preamble_nitems = 61):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Frequency Shift Detector',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.SF = SF
              self.preamble_nitems = preamble_nitems
              self.symbcounter = 0
              self.SF = SF
              self.f_up = 5555555
              self.f_down = 1693653
              self.set_output_multiple(preamble_nitems)

          def work(self, input_items, output_items):

              self.symbcounter += 1 
              M = pow(2,self.SF)
              freq_vect = np.arange(0,M)
              base_downchirp = modulate(self.SF, 0, 1, -1)
              base_upchirp = modulate(self.SF, 0, 1, 1)

              if self.symbcounter == 1 :
                  in0 = input_items[0][:512]
                  demod_signal = np.multiply(in0, base_downchirp)   # multiply every symbol with the downchirp
                  demod_signal_fft = np.fft.fft(demod_signal)                     # perform FFT on demodulated signal    
                  idx = np.argmax(np.abs(demod_signal_fft))                       # find the frequency index of the maximum value
                  self.f_up = round(round(freq_vect[idx]))               # convert the frequency index to symbol index
                  print("[RX] Freq.   : f_up = ", self.f_up)


              output_items[0][:len(input_items[0][:self.preamble_nitems])] = input_items[0][:self.preamble_nitems]
              return len(input_items[0][:self.preamble_nitems])
    preamble_nitems: '61'
  states: {state: disabled}
- name: epy_block_5
  id: epy_block
  parameters:
    B: '250000'
    SF: SF
    _source_code: |
      """
      Demodulation Block:
      Reference : "Towards an SDR implementation of LoRa..." 2020 A.Marquet, N.Montavont, G.Papadopoulos)

      INPUT:
          - in_sig[0]: IQ complex vectors input sequence
      OUTPUT:
          - out_sig[0]: 
      """

      import numpy as np
      from gnuradio import gr
      import math
      import matplotlib.pyplot as plt
      # def modulate(SF, id, os_factor) :
      #     M  = pow(2,SF)
      #     n_fold = M * os_factor - id * os_factor
      #     chirp = np.zeros(M*os_factor, dtype=np.complex64)
      #     for n in range(0,M*os_factor):
      #         if n < n_fold:
      #             chirp[n] = np.exp(2j*math.pi *(n*n/(2*M)/pow(os_factor,2)+(id/M-0.5)*n/os_factor))
      #         else:
      #             chirp[n] = np.exp(2j*math.pi *(n*n/(2*M)/pow(os_factor,2)+(id/M-1.5)*n/os_factor))
      #     return chirp

      def modulate(SF, id, os_factor, sign) :
          M  = pow(2,SF)*os_factor
          ka = np.arange(0,M)
          fact1 = np.exp(1j*sign*math.pi*(pow(ka,2))/M)
          chirp = fact1*np.exp(2j*math.pi*(id/M)*ka)
          return chirp

      class Demodulation(gr.sync_block):

          def __init__(self, SF = 9, B = 250000, os_factor = 1):
              gr.sync_block.__init__(
                  self,
                  name='LoRa Demodulation',
                  in_sig=[(np.complex64,pow(2,SF)*os_factor)],
                  out_sig=[np.uint32]
              )
              self.SF = SF
              self.B = B
              self.os_factor = os_factor

          def work(self, input_items, output_items):

              M = pow(2,self.SF)

              base_downchirp = modulate(self.SF, 0, self.os_factor, -1)
              freq_vect = np.arange(0,M*self.os_factor)                                    # !!!! WILL INTRODUCE PROBLEMS WHEN OS_FACTOR IS NOT 1 !!!!
              max_array = np.zeros(len(input_items[0]), dtype=np.float32)
              
              for i in range(len(input_items[0])):
                  demod_signal = np.multiply(input_items[0][i], base_downchirp)   # multiply every symbol with the downchirp
                  demod_signal_fft = np.fft.fft(demod_signal)                     # perform FFT on demodulated signal    
                  idx = np.argmax(np.abs(demod_signal_fft))                       # find the frequency index of the maximum value
                  output_items[0][i] = round(round(freq_vect[idx]))               # convert the frequency index to symbol index
                  # debug
                  max_array[i] = np.max(np.abs(demod_signal_fft[idx]))

                  # vect = np.arange(0,M)
                  # fig, axs = plt.subplots(2)
                  # fig.suptitle('Vertically stacked subplots')
                  # axs[0].specgram(input_items[0][i], NFFT=64, Fs=32, noverlap=8)
                  # axs[1].plot(vect, np.abs(demod_signal_fft))
                  # plt.show()   

                  # print("[RX] Demod.  : max (should be 2**SF):", max_array[i])
                  # if max_array[i] < 2**self.SF:
                  # print("[RX] Demod.  :  max_array[i] < 2**self.SF :", max_array[i])

              # # debug
              # print("\n--- GENERAL WORK : DEMODULATION ---")
              # print("[RX] Demod.  : mean max (should be 2**SF):", np.mean(max_array))
              # print("[RX] Demod.  : nreceived symbols:", i)
              return len(output_items[0])
    os_factor: os_factor
  states: {state: disabled}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, preamble_nitems = 4224, payload_nitems = 8192, padding = 100):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='LoRa Frame Constructor',   # will show up in GRC\n            in_sig=[(np.complex64,preamble_nitems),(np.complex64,payload_nitems)],\n            out_sig=[(np.complex64,padding+preamble_nitems+payload_nitems)]\n        )\n        self.payload_nitems = payload_nitems\n        self.preamble_nitems = preamble_nitems\n        self.frame_counter = 0\n        self.padding = padding\n\n        \n    def work(self, input_items, output_items):\n        if len(input_items[0][0]) == self.preamble_nitems and len(input_items[1][0]) == self.payload_nitems :\n            frame = np.concatenate((input_items[0],input_items[1]),axis=1)\n            output_items[0][:] = np.concatenate((0.1*np.ones((1,self.padding)), frame),axis=1)\n            # print(np.shape(output_items[0][:]))\n            # TAGS\n            key = pmt.intern(\"tx_sob\")\n            value = pmt.from_bool(True)\n            self.add_item_tag(0, # Write to output port 0\n                    self.nitems_written(0), # Index of the tag in absolute terms\n                    key, # Key of the tag\n                    value # Value of the tag\n            )\n            # tx_time tag is optional : https://discuss-gnuradio.gnu.narkive.com/c2r83OZW/uhd-usrp-sink-stream-tagging\n            # TAGS\n            key = pmt.intern(\"packet_len\")\n            value = pmt.from_long(self.preamble_nitems+self.payload_nitems+self.padding)\n            self.add_item_tag(0, # Write to output port 0\n                    self.nitems_written(0), # Index of the tag in absolute terms\n                    key, # Key of the tag\n                    value # Value of the tag\n            )\n\n            self.frame_counter += 1\n            print(\"\\n\\n[TX] Constr. : Frame #%d sent\" % (self.frame_counter))\n            return len(output_items[0])\n        else :\n            return 0\n        # out = np.concatenate((input_items[0][0],input_items[1][0]))\n        # print(len(out))\n        # output_items[0][:] = out\n        \n"
    padding: padding
    payload_nitems: '8192'
    preamble_nitems: '4224'
  states: {}
- name: epy_block_6_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Tagged Stream Cropper:
      Reference : https://dsp.stackexchange.com/questions/80751/gnu-radiotagged-stream-how-to-clip-the-stream-as-packet-length-tag-long

      INPUTS:
          - in_sig[0]: IQ complex stream
      OUTPUT:
          - out_sig[0]: IQ complex stream
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class my_basic_adder_block(gr.basic_block):
          def __init__(self,tag_name = 'packet_len'):
              gr.basic_block.__init__(self,
                                      name="Tagged Stream Cropper",
                                      in_sig  = [np.complex64],
                                      out_sig = [np.complex64])

              self.previous_tag_n_remainder = 0
              self.tag_name                 = tag_name
              self.set_tag_propagation_policy(gr.TPP_DONT)

          def general_work(self, input_items, output_items):
              len_out = len(output_items[0])

              # DO PROCESSING
              out_produced = 0 # output produced 

              #-> Write the remaining data of the previous tag
              if self.previous_tag_n_remainder > 0: 
                  if self.previous_tag_n_remainder < len_out: # if the length of the input items is sufficient to write the remainder of the previous tag items 
                      output_items[0][:self.previous_tag_n_remainder] = input_items[0][:self.previous_tag_n_remainder] #write to output 
                      out_produced                                   += self.previous_tag_n_remainder                  #inccrease the number of item produced
                      self.previous_tag_n_remainder = 0                                                                #reset the counter 
                      # the RETURN is at the end of the work()

                  else: # self.previous_tag_n_remainder >= len_out
                      output_items[0][:len_out]      = input_items[0][:len_out]
                      self.previous_tag_n_remainder -= len_out
                      self.consume(0, len_out)
                      return len_out

              # READ TAGS AND PARSE THE RECEIVED STREAM
              tags = self.get_tags_in_window(0, out_produced, len_out)

              #if there exist tag
              if len(tags) > 0:
                  #for each tag apply
                  for tag in tags:
                      tag_name   = pmt.to_python(tag.key)            # packet_tag
                      tag_len    = int(pmt.to_python(tag.value))          # packet_len
                      tag_pos    = tag.offset - self.nitems_read(0)  # packet_position_index
                      if tag_name == self.tag_name:       #check if the tag name is appropriate
                          # print("[TX] Cropper : Tag found at position {} with length {}".format(tag_pos,tag_len))
                          if tag_pos + tag_len < len_out: # if all the elements correspding to the "tag" are included in the input_items

                              # write the elements to the output
                              output_items[0][out_produced:(out_produced+tag_len)] = input_items[0][tag_pos:(tag_pos+tag_len)]

                              # add tag to the corresponding start point                     
                              self.add_item_tag(0,                                   # Write to output port 0
                                               self.nitems_written(0)+out_produced,  # Index of the tag in absolute terms
                                               tag.key,                              # Key of the tag
                                               tag.value                             # Value of the tag
                                               )
                              #increase the number of output element produced counter
                              out_produced += tag_len

                          else: #tag_pos+tag_len >= len_out:
                              n_item_to_wrt = len_out - tag_pos
                              output_items[0][out_produced:(out_produced + n_item_to_wrt)] = input_items[0][tag_pos:(tag_pos+n_item_to_wrt)]

                              self.add_item_tag(0,                                     # Write to output port 0
                                                self.nitems_written(0)+out_produced,   # Index of the tag in absolute terms
                                                tag.key,                               # Key of the tag
                                                tag.value                              # Value of the tag
                                                )

                              self.previous_tag_n_remainder = tag_len - n_item_to_wrt
                              out_produced                 += n_item_to_wrt
                              self.consume(0,len_out)
                              return out_produced

              #if there is no tag exits
              self.consume(0,len_out)

              #recall that the first "if" state is producing element!
              return out_produced

      # """
      # Preamble removal block
      # Correlation method
      # """

      # import numpy as np
      # from gnuradio import gr
      # import pmt

      # class Preamble_Remover(gr.basic_block):
      #     def __init__(self, SF=9, preamble_len = 6):
      #         gr.basic_block.__init__(self,
      #             name="LoRa Preamble Remover",
      #             in_sig=[(np.complex64)],
      #             out_sig=[(np.complex64)])
      #         self.SF = SF

      #     def forecast(self, noutput_items, ninputs) :
      #         ninput_items_required = [1]*ninputs #ninput_items_required[i] is the number of items that will be consumed on input port i
      #         return ninput_items_required

      #     def general_work(self, input_items, output_items):

      #         #buffer references
      #         in0 = input_items[0] #input signal

      #         tags = self.get_tags_in_window(0, 0, len(input_items[0]))
      #         for tag in tags:
      #             key = pmt.to_python(tag.key) # convert from PMT to python string
      #             value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was
      #             print('key:', key)
      #             print('value:', value, type(value))
      #             print('')
      #             croppedInput = in0[int(value):]
      #             output_items[0][0:len(in0)] = croppedInput[:len(output_items[0])]
      #             self.consume(0, len(in0[:len(output_items[0])]))
      #         return len(in0[:len(output_items[0])])
    tag_name: '"payload_begin"'
  states: {state: disabled}
- name: epy_block_6_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Tagged Stream Cropper:
      Reference : https://dsp.stackexchange.com/questions/80751/gnu-radiotagged-stream-how-to-clip-the-stream-as-packet-length-tag-long

      INPUTS:
          - in_sig[0]: IQ complex stream
      OUTPUT:
          - out_sig[0]: IQ complex stream
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class my_basic_adder_block(gr.basic_block):
          def __init__(self,tag_name = 'packet_len'):
              gr.basic_block.__init__(self,
                                      name="Tagged Stream Cropper",
                                      in_sig  = [np.complex64],
                                      out_sig = [np.complex64])

              self.previous_tag_n_remainder = 0
              self.tag_name                 = tag_name
              self.set_tag_propagation_policy(gr.TPP_DONT)

          def general_work(self, input_items, output_items):
              len_out = len(output_items[0])

              # DO PROCESSING
              out_produced = 0 # output produced 

              #-> Write the remaining data of the previous tag
              if self.previous_tag_n_remainder > 0: 
                  if self.previous_tag_n_remainder < len_out: # if the length of the input items is sufficient to write the remainder of the previous tag items 
                      output_items[0][:self.previous_tag_n_remainder] = input_items[0][:self.previous_tag_n_remainder] #write to output 
                      out_produced                                   += self.previous_tag_n_remainder                  #inccrease the number of item produced
                      self.previous_tag_n_remainder = 0                                                                #reset the counter 
                      # the RETURN is at the end of the work()

                  else: # self.previous_tag_n_remainder >= len_out
                      output_items[0][:len_out]      = input_items[0][:len_out]
                      self.previous_tag_n_remainder -= len_out
                      self.consume(0, len_out)
                      return len_out

              # READ TAGS AND PARSE THE RECEIVED STREAM
              tags = self.get_tags_in_window(0, out_produced, len_out)

              #if there exist tag
              if len(tags) > 0:
                  #for each tag apply
                  for tag in tags:
                      tag_name   = pmt.to_python(tag.key)            # packet_tag
                      tag_len    = int(pmt.to_python(tag.value))          # packet_len
                      tag_pos    = tag.offset - self.nitems_read(0)  # packet_position_index
                      if tag_name == self.tag_name:       #check if the tag name is appropriate
                          # print("[TX] Cropper : Tag found at position {} with length {}".format(tag_pos,tag_len))
                          if tag_pos + tag_len < len_out: # if all the elements correspding to the "tag" are included in the input_items

                              # write the elements to the output
                              output_items[0][out_produced:(out_produced+tag_len)] = input_items[0][tag_pos:(tag_pos+tag_len)]

                              # add tag to the corresponding start point                     
                              self.add_item_tag(0,                                   # Write to output port 0
                                               self.nitems_written(0)+out_produced,  # Index of the tag in absolute terms
                                               tag.key,                              # Key of the tag
                                               tag.value                             # Value of the tag
                                               )
                              #increase the number of output element produced counter
                              out_produced += tag_len

                          else: #tag_pos+tag_len >= len_out:
                              n_item_to_wrt = len_out - tag_pos
                              output_items[0][out_produced:(out_produced + n_item_to_wrt)] = input_items[0][tag_pos:(tag_pos+n_item_to_wrt)]

                              self.add_item_tag(0,                                     # Write to output port 0
                                                self.nitems_written(0)+out_produced,   # Index of the tag in absolute terms
                                                tag.key,                               # Key of the tag
                                                tag.value                              # Value of the tag
                                                )

                              self.previous_tag_n_remainder = tag_len - n_item_to_wrt
                              out_produced                 += n_item_to_wrt
                              self.consume(0,len_out)
                              return out_produced

              #if there is no tag exits
              self.consume(0,len_out)

              #recall that the first "if" state is producing element!
              return out_produced

      # """
      # Preamble removal block
      # Correlation method
      # """

      # import numpy as np
      # from gnuradio import gr
      # import pmt

      # class Preamble_Remover(gr.basic_block):
      #     def __init__(self, SF=9, preamble_len = 6):
      #         gr.basic_block.__init__(self,
      #             name="LoRa Preamble Remover",
      #             in_sig=[(np.complex64)],
      #             out_sig=[(np.complex64)])
      #         self.SF = SF

      #     def forecast(self, noutput_items, ninputs) :
      #         ninput_items_required = [1]*ninputs #ninput_items_required[i] is the number of items that will be consumed on input port i
      #         return ninput_items_required

      #     def general_work(self, input_items, output_items):

      #         #buffer references
      #         in0 = input_items[0] #input signal

      #         tags = self.get_tags_in_window(0, 0, len(input_items[0]))
      #         for tag in tags:
      #             key = pmt.to_python(tag.key) # convert from PMT to python string
      #             value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was
      #             print('key:', key)
      #             print('value:', value, type(value))
      #             print('')
      #             croppedInput = in0[int(value):]
      #             output_items[0][0:len(in0)] = croppedInput[:len(output_items[0])]
      #             self.consume(0, len(in0[:len(output_items[0])]))
      #         return len(in0[:len(output_items[0])])
    tag_name: '"threshold_exceeded"'
  states: {state: disabled}
- name: epy_block_6_0_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Tagged Stream Cropper:
      Reference : https://dsp.stackexchange.com/questions/80751/gnu-radiotagged-stream-how-to-clip-the-stream-as-packet-length-tag-long

      INPUTS:
          - in_sig[0]: IQ complex stream
      OUTPUT:
          - out_sig[0]: IQ complex stream
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class my_basic_adder_block(gr.basic_block):
          def __init__(self,tag_name = 'packet_len', len = 12):
              gr.basic_block.__init__(self,
                                      name="Tagged Stream Cropper",
                                      in_sig  = [np.complex64],
                                      out_sig = [np.complex64])

              self.previous_tag_n_remainder = 0
              self.tag_name                 = tag_name
              self.set_tag_propagation_policy(gr.TPP_DONT)
              self.len = len

          def general_work(self, input_items, output_items):
              len_out = len(output_items[0])

              # DO PROCESSING
              out_produced = 0 # output produced 

              #-> Write the remaining data of the previous tag
              if self.previous_tag_n_remainder > 0: 
                  if self.previous_tag_n_remainder < len_out: # if the length of the input items is sufficient to write the remainder of the previous tag items 
                      output_items[0][:self.previous_tag_n_remainder] = input_items[0][:self.previous_tag_n_remainder] #write to output 
                      out_produced                                   += self.previous_tag_n_remainder                  #inccrease the number of item produced
                      self.previous_tag_n_remainder = 0                                                                #reset the counter 
                      # the RETURN is at the end of the work()

                  else: # self.previous_tag_n_remainder >= len_out
                      output_items[0][:len_out]      = input_items[0][:len_out]
                      self.previous_tag_n_remainder -= len_out
                      self.consume(0, len_out)
                      return len_out

              # READ TAGS AND PARSE THE RECEIVED STREAM
              tags = self.get_tags_in_window(0, out_produced, len_out)

              #if there exist tag
              if len(tags) > 0:
                  #for each tag apply
                  for tag in tags:
                      tag_name   = pmt.to_python(tag.key)            # packet_tag
                      tag_len    = self.len          # packet_len
                      tag_pos    = tag.offset - self.nitems_read(0)  # packet_position_index
                      if tag_name == self.tag_name:       #check if the tag name is appropriate
                          print("[TX] Cropper : Tag found at position {} with length {}".format(tag_pos,tag_len))
                          if tag_pos + tag_len < len_out: # if all the elements correspding to the "tag" are included in the input_items

                              # write the elements to the output
                              output_items[0][out_produced:(out_produced+tag_len)] = input_items[0][tag_pos:(tag_pos+tag_len)]

                              # add tag to the corresponding start point                     
                              self.add_item_tag(0,                                   # Write to output port 0
                                               self.nitems_written(0)+out_produced,  # Index of the tag in absolute terms
                                               tag.key,                              # Key of the tag
                                               tag.value                             # Value of the tag
                                               )
                              #increase the number of output element produced counter
                              out_produced += tag_len

                          else: #tag_pos+tag_len >= len_out:
                              n_item_to_wrt = len_out - tag_pos
                              output_items[0][out_produced:(out_produced + n_item_to_wrt)] = input_items[0][tag_pos:(tag_pos+n_item_to_wrt)]

                              self.add_item_tag(0,                                     # Write to output port 0
                                                self.nitems_written(0)+out_produced,   # Index of the tag in absolute terms
                                                tag.key,                               # Key of the tag
                                                tag.value                              # Value of the tag
                                                )

                              self.previous_tag_n_remainder = tag_len - n_item_to_wrt
                              out_produced                 += n_item_to_wrt
                              self.consume(0,len_out)
                              return out_produced

              #if there is no tag exits
              self.consume(0,len_out)

              #recall that the first "if" state is producing element!
              return out_produced

      # """
      # Preamble removal block
      # Correlation method
      # """

      # import numpy as np
      # from gnuradio import gr
      # import pmt

      # class Preamble_Remover(gr.basic_block):
      #     def __init__(self, SF=9, preamble_len = 6):
      #         gr.basic_block.__init__(self,
      #             name="LoRa Preamble Remover",
      #             in_sig=[(np.complex64)],
      #             out_sig=[(np.complex64)])
      #         self.SF = SF

      #     def forecast(self, noutput_items, ninputs) :
      #         ninput_items_required = [1]*ninputs #ninput_items_required[i] is the number of items that will be consumed on input port i
      #         return ninput_items_required

      #     def general_work(self, input_items, output_items):

      #         #buffer references
      #         in0 = input_items[0] #input signal

      #         tags = self.get_tags_in_window(0, 0, len(input_items[0]))
      #         for tag in tags:
      #             key = pmt.to_python(tag.key) # convert from PMT to python string
      #             value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was
      #             print('key:', key)
      #             print('value:', value, type(value))
      #             print('')
      #             croppedInput = in0[int(value):]
      #             output_items[0][0:len(in0)] = croppedInput[:len(output_items[0])]
      #             self.consume(0, len(in0[:len(output_items[0])]))
      #         return len(in0[:len(output_items[0])])
    len: preamble_nitems
    tag_name: '"threshold_exceeded"'
  states: {state: disabled}
- name: epy_block_6_0_0_0_0_0
  id: epy_block
  parameters:
    SF: SF
    _source_code: |-
      """
      Modulation Block:
      Reference : "Towards an SDR implementation of LoRa..." 2020 A.Marquet, N.Montavont, G.Papadopoulos)

      INPUT:
          - in_sig[0]: int32 input stream
      OUTPUT:
          - out_sig[0]: IQ complex vectors output stream
      """

      import numpy as np
      from gnuradio import gr
      import math
      import time

      # def modulate(SF, id, os_factor, sign) :
      #     M  = pow(2,SF)
      #     n_fold = M * os_factor - id * os_factor
      #     chirp = np.zeros(M*os_factor, dtype=np.complex64)
      #     for n in range(0,M*os_factor):
      #         if n < n_fold:
      #             chirp[n] = np.exp(2j*math.pi *(n*n/(2*M)/pow(os_factor,2)+(id/M-0.5)*n/os_factor))
      #         else:
      #             chirp[n] = np.exp(2j*math.pi *(n*n/(2*M)/pow(os_factor,2)+(id/M-1.5)*n/os_factor))
      #     return chirp

      def modulate(SF, id, os_factor, sign) :
          M  = pow(2,SF)
          ka = np.arange(0,M)
          fact1 = np.exp(1j*sign*math.pi*(pow(ka,2))/M)
          chirp = fact1*np.exp(2j*math.pi*(id/M)*ka)

          return chirp

      class Modulation(gr.sync_block):
          def __init__(self, SF = 9):
              gr.sync_block.__init__(
                  self,
                  name='LoRa Modulation',
                  in_sig=[np.uint32],
                  out_sig=[(np.complex64,pow(2,SF))]
              )
              self.SF = SF
              self.set_tag_propagation_policy(gr.TPP_DONT)
              
          def work(self, input_items, output_items):

              symbols = input_items[0]
              for i in range (len(symbols)) :
                  output_items[0][i] = modulate(self.SF, symbols[i], 1, 1)   # modulate every symbol
              return len(output_items[0])
  states: {}
- name: epy_block_6_0_0_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Tagged Stream Cropper:
      Reference : https://dsp.stackexchange.com/questions/80751/gnu-radiotagged-stream-how-to-clip-the-stream-as-packet-length-tag-long

      INPUTS:
          - in_sig[0]: IQ complex stream
      OUTPUT:
          - out_sig[0]: IQ complex stream
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class my_basic_adder_block(gr.basic_block):
          def __init__(self,tag_name = 'packet_len'):
              gr.basic_block.__init__(self,
                                      name="Tagged Stream Cropper",
                                      in_sig  = [np.complex64],
                                      out_sig = [np.complex64])

              self.previous_tag_n_remainder = 0
              self.tag_name                 = tag_name
              self.set_tag_propagation_policy(gr.TPP_DONT)

          def general_work(self, input_items, output_items):
              len_out = len(output_items[0])

              # DO PROCESSING
              out_produced = 0 # output produced 

              #-> Write the remaining data of the previous tag
              if self.previous_tag_n_remainder > 0: 
                  if self.previous_tag_n_remainder < len_out: # if the length of the input items is sufficient to write the remainder of the previous tag items 
                      output_items[0][:self.previous_tag_n_remainder] = input_items[0][:self.previous_tag_n_remainder] #write to output 
                      out_produced                                   += self.previous_tag_n_remainder                  #inccrease the number of item produced
                      self.previous_tag_n_remainder = 0                                                                #reset the counter 
                      # the RETURN is at the end of the work()

                  else: # self.previous_tag_n_remainder >= len_out
                      output_items[0][:len_out]      = input_items[0][:len_out]
                      self.previous_tag_n_remainder -= len_out
                      self.consume(0, len_out)
                      return len_out

              # READ TAGS AND PARSE THE RECEIVED STREAM
              tags = self.get_tags_in_window(0, out_produced, len_out)

              #if there exist tag
              if len(tags) > 0:
                  #for each tag apply
                  for tag in tags:
                      tag_name   = pmt.to_python(tag.key)            # packet_tag
                      tag_len    = int(pmt.to_python(tag.value))          # packet_len
                      tag_pos    = tag.offset - self.nitems_read(0)  # packet_position_index
                      if tag_name == self.tag_name:       #check if the tag name is appropriate
                          print("[TX] Cropper : Tag found at position {} with length {}".format(tag_pos,tag_len))
                          if tag_pos + tag_len < len_out: # if all the elements correspding to the "tag" are included in the input_items

                              # write the elements to the output
                              output_items[0][out_produced:(out_produced+tag_len)] = input_items[0][tag_pos:(tag_pos+tag_len)]

                              # add tag to the corresponding start point                     
                              self.add_item_tag(0,                                   # Write to output port 0
                                               self.nitems_written(0)+out_produced,  # Index of the tag in absolute terms
                                               tag.key,                              # Key of the tag
                                               tag.value                             # Value of the tag
                                               )
                              #increase the number of output element produced counter
                              out_produced += tag_len

                          else: #tag_pos+tag_len >= len_out:
                              n_item_to_wrt = len_out - tag_pos
                              output_items[0][out_produced:(out_produced + n_item_to_wrt)] = input_items[0][tag_pos:(tag_pos+n_item_to_wrt)]

                              self.add_item_tag(0,                                     # Write to output port 0
                                                self.nitems_written(0)+out_produced,   # Index of the tag in absolute terms
                                                tag.key,                               # Key of the tag
                                                tag.value                              # Value of the tag
                                                )

                              self.previous_tag_n_remainder = tag_len - n_item_to_wrt
                              out_produced                 += n_item_to_wrt
                              self.consume(0,len_out)
                              return out_produced

              #if there is no tag exits
              self.consume(0,len_out)

              #recall that the first "if" state is producing element!
              return out_produced

      # """
      # Preamble removal block
      # Correlation method
      # """

      # import numpy as np
      # from gnuradio import gr
      # import pmt

      # class Preamble_Remover(gr.basic_block):
      #     def __init__(self, SF=9, preamble_len = 6):
      #         gr.basic_block.__init__(self,
      #             name="LoRa Preamble Remover",
      #             in_sig=[(np.complex64)],
      #             out_sig=[(np.complex64)])
      #         self.SF = SF

      #     def forecast(self, noutput_items, ninputs) :
      #         ninput_items_required = [1]*ninputs #ninput_items_required[i] is the number of items that will be consumed on input port i
      #         return ninput_items_required

      #     def general_work(self, input_items, output_items):

      #         #buffer references
      #         in0 = input_items[0] #input signal

      #         tags = self.get_tags_in_window(0, 0, len(input_items[0]))
      #         for tag in tags:
      #             key = pmt.to_python(tag.key) # convert from PMT to python string
      #             value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was
      #             print('key:', key)
      #             print('value:', value, type(value))
      #             print('')
      #             croppedInput = in0[int(value):]
      #             output_items[0][0:len(in0)] = croppedInput[:len(output_items[0])]
      #             self.consume(0, len(in0[:len(output_items[0])]))
      #         return len(in0[:len(output_items[0])])
    tag_name: '"threshold_exceeded"'
  states: {state: disabled}
- name: epy_block_6_0_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Tagged Stream Cropper:
      Reference : https://dsp.stackexchange.com/questions/80751/gnu-radiotagged-stream-how-to-clip-the-stream-as-packet-length-tag-long

      INPUTS:
          - in_sig[0]: IQ complex stream
      OUTPUT:
          - out_sig[0]: IQ complex stream
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class my_basic_adder_block(gr.basic_block):
          def __init__(self,tag_name = 'packet_len'):
              gr.basic_block.__init__(self,
                                      name="Tagged Stream Cropper",
                                      in_sig  = [np.complex64],
                                      out_sig = [np.complex64])

              self.previous_tag_n_remainder = 0
              self.tag_name                 = tag_name
              self.set_tag_propagation_policy(gr.TPP_DONT)

          def general_work(self, input_items, output_items):
              len_out = len(output_items[0])

              # DO PROCESSING
              out_produced = 0 # output produced 

              #-> Write the remaining data of the previous tag
              if self.previous_tag_n_remainder > 0: 
                  if self.previous_tag_n_remainder < len_out: # if the length of the input items is sufficient to write the remainder of the previous tag items 
                      output_items[0][:self.previous_tag_n_remainder] = input_items[0][:self.previous_tag_n_remainder] #write to output 
                      out_produced                                   += self.previous_tag_n_remainder                  #inccrease the number of item produced
                      self.previous_tag_n_remainder = 0                                                                #reset the counter 
                      # the RETURN is at the end of the work()

                  else: # self.previous_tag_n_remainder >= len_out
                      output_items[0][:len_out]      = input_items[0][:len_out]
                      self.previous_tag_n_remainder -= len_out
                      self.consume(0, len_out)
                      return len_out

              # READ TAGS AND PARSE THE RECEIVED STREAM
              tags = self.get_tags_in_window(0, out_produced, len_out)

              #if there exist tag
              if len(tags) > 0:
                  #for each tag apply
                  for tag in tags:
                      tag_name   = pmt.to_python(tag.key)            # packet_tag
                      tag_len    = int(pmt.to_python(tag.value))          # packet_len
                      tag_pos    = tag.offset - self.nitems_read(0)  # packet_position_index
                      if tag_name == self.tag_name:       #check if the tag name is appropriate
                          # print("[TX] Cropper : Tag found at position {} with length {}".format(tag_pos,tag_len))
                          if tag_pos + tag_len < len_out: # if all the elements correspding to the "tag" are included in the input_items

                              # write the elements to the output
                              output_items[0][out_produced:(out_produced+tag_len)] = input_items[0][tag_pos:(tag_pos+tag_len)]

                              # add tag to the corresponding start point                     
                              self.add_item_tag(0,                                   # Write to output port 0
                                               self.nitems_written(0)+out_produced,  # Index of the tag in absolute terms
                                               tag.key,                              # Key of the tag
                                               tag.value                             # Value of the tag
                                               )
                              #increase the number of output element produced counter
                              out_produced += tag_len

                          else: #tag_pos+tag_len >= len_out:
                              n_item_to_wrt = len_out - tag_pos
                              output_items[0][out_produced:(out_produced + n_item_to_wrt)] = input_items[0][tag_pos:(tag_pos+n_item_to_wrt)]

                              self.add_item_tag(0,                                     # Write to output port 0
                                                self.nitems_written(0)+out_produced,   # Index of the tag in absolute terms
                                                tag.key,                               # Key of the tag
                                                tag.value                              # Value of the tag
                                                )

                              self.previous_tag_n_remainder = tag_len - n_item_to_wrt
                              out_produced                 += n_item_to_wrt
                              self.consume(0,len_out)
                              return out_produced

              #if there is no tag exits
              self.consume(0,len_out)

              #recall that the first "if" state is producing element!
              return out_produced

      # """
      # Preamble removal block
      # Correlation method
      # """

      # import numpy as np
      # from gnuradio import gr
      # import pmt

      # class Preamble_Remover(gr.basic_block):
      #     def __init__(self, SF=9, preamble_len = 6):
      #         gr.basic_block.__init__(self,
      #             name="LoRa Preamble Remover",
      #             in_sig=[(np.complex64)],
      #             out_sig=[(np.complex64)])
      #         self.SF = SF

      #     def forecast(self, noutput_items, ninputs) :
      #         ninput_items_required = [1]*ninputs #ninput_items_required[i] is the number of items that will be consumed on input port i
      #         return ninput_items_required

      #     def general_work(self, input_items, output_items):

      #         #buffer references
      #         in0 = input_items[0] #input signal

      #         tags = self.get_tags_in_window(0, 0, len(input_items[0]))
      #         for tag in tags:
      #             key = pmt.to_python(tag.key) # convert from PMT to python string
      #             value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was
      #             print('key:', key)
      #             print('value:', value, type(value))
      #             print('')
      #             croppedInput = in0[int(value):]
      #             output_items[0][0:len(in0)] = croppedInput[:len(output_items[0])]
      #             self.consume(0, len(in0[:len(output_items[0])]))
      #         return len(in0[:len(output_items[0])])
    tag_name: '"preamble_begin"'
  states: {state: disabled}
- name: epy_block_7
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: ''
  states: {state: disabled}
- name: epy_block_7_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          def __init__(self, preamble_nitems = 4224, payload_nitems = 8192, padding = 10):
              gr.sync_block.__init__(
                  self,
                  name='LoRa EoB Tagger',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.payload_nitems = payload_nitems
              self.preamble_nitems = preamble_nitems
              self.frame_counter = 0
              self.padding = padding

          def work(self, input_items, output_items):

              tags = self.get_tags_in_window(0, 0, len(input_items[0]))
              for tag in tags:
                  if pmt.to_python(tag.key) == "tx_sob" :
                      key = pmt.intern("tx_eob")
                      value = pmt.from_bool(True)
                      self.add_item_tag(0, # Write to output port 0
                              self.nitems_written(0) + self.padding + self.payload_nitems + self.preamble_nitems-1, # Index of the tag in absolute terms
                              key, # Key of the tag
                              value # Value of the tag
                      )
                      self.frame_counter += 1
                      # print("\n\n[TX] Constr. : Frame #%d sent" % (self.frame_counter))
              output_items[0][:] = input_items[0]

              return len(output_items[0])
    padding: padding
    payload_nitems: payload_nitems
    preamble_nitems: preamble_nitems
  states: {}
- name: epy_block_8
  id: epy_block
  parameters:
    SF: '9'
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):

          def __init__(self, SF=1):
              gr.sync_block.__init__(
                  self,
                  name='LoRa Gray Tx',
                  in_sig=[np.int32],
                  out_sig=[np.int32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.SF = SF

          def work(self, input_items, output_items):
              in0 = input_items[0][:len(output_items[0])]
              out = output_items[0]

              for i in range(len(out)):
                  out[i] = in0[i] ^ (in0[i] >> 1)
              return len(output_items[0])
  states: {}
- name: epy_block_8_0
  id: epy_block
  parameters:
    SF: '9'
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):

          def __init__(self, SF=1):
              gr.sync_block.__init__(
                  self,
                  name='LoRa Gray Rx',
                  in_sig=[np.int32],
                  out_sig=[np.int32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.SF = SF

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              in0 = input_items[0][:len(output_items[0])]
              out = output_items[0]

              for i in range(len(out)):
                  out[i] = in0[i]
                  for j in range(1,self.SF):
                      out[i]= out[i] ^ (in0[i] >> j)
              return len(output_items[0])
  states: {state: disabled}
- name: epy_block_9
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import matplotlib.pyplot as plt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,preamble_nitems = 24, payload_nitems = 1, threshold = 10000):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='LoRa Threshold Sync',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              
              self.preamble_nitems = preamble_nitems
              self.payload_nitems = payload_nitems
              self.threshold = threshold
              self.items_written0_old = 0

              self.state = 0 # 0 if searching for preamble, 1 if found
              self.last_tag = 0
              self.set_output_multiple(self.preamble_nitems + self.payload_nitems + 1000)

          def work(self, input_items, output_items):

              in0 = input_items[0][:len(output_items[0])]


              if self.state == 0 :
                  threshold_in0 = np.where(in0 > self.threshold)
                  if len(threshold_in0[0]) > 0:
                      print("\n[RX] thresh. : Power threshold exceeded")
                      # print("fast : ", threshold_in0[0][0])
                      self.state = 1
                      tag_index = self.nitems_read(0) + threshold_in0[0][0]
                      # print(self.nitems_read(0), threshold_in0[0][0])
                      self.add_item_tag(0,tag_index,  pmt.intern("threshold_exceeded"),  pmt.intern(str(self.preamble_nitems + self.payload_nitems + 1000)))
                      self.last_tag = tag_index
                      self.items_written0_old = self.nitems_written(0)
                      # # # debug
                      # vect = np.arange(0,len(in0))
                      # plt.plot(vect, np.real(in0))
                      # plt.axvline(threshold_in0[0][0], 0, 1, color = "red", label = "Corr peak idx")
                      # # plt.specgram(in0, NFFT=64, Fs=32, noverlap=8)
                      # plt.show()
                      

              if self.state == 1 :
                  if self.nitems_written(0) - self.items_written0_old > self.payload_nitems*2:
                      # print("Reset")
                      self.state = 0
                  pass

              output_items[0][:] = in0
              return len(output_items[0])
    payload_nitems: payload_nitems*os_factor
    preamble_nitems: preamble_nitems*os_factor
    threshold: threshold
  states: {state: disabled}
- name: epy_block_9_0
  id: epy_block
  parameters:
    SF: '9'
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import matplotlib.pyplot as plt
      import math

      def modulate_vect(SF, id, os_factor, sign) :
          M  = pow(2,SF)
          ka = np.arange(0,M)
          fact1 = np.exp(1j*sign*math.pi*(pow(ka,2))/M)
          chirp = np.zeros((len(id),M*os_factor), dtype=np.complex64)
          for i in range(len(id)) :
              chirp[i] = fact1*np.exp(2j*math.pi*(id[i]/M)*ka)
          return chirp

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,preamble_len = 6, payload_nitems = 1, threshold = 10000, SF = 1):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='LoRa Correlation Sync Payload',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              
              self.preamble_len = preamble_len
              self.preamble_nitems = round(pow(2,SF)*(preamble_len+2.25))
              self.payload_nitems = payload_nitems
              self.threshold = threshold
              self.SF = SF

              self.state = 0 # 0 if searching for preamble, 1 if found
              self.items_written0_old = 0
              self.set_output_multiple(self.preamble_nitems + self.payload_nitems + 1000)
              # self.set_history(4224+1)

          def work(self, input_items, output_items):

              in0 = input_items[0]
              # fig, axs = plt.subplots(3)
              # # axs[0].specgram(in0, NFFT=64, Fs=32, noverlap=8)
              # axs[0].plot(np.arange(0, len(in0)), in0)
              # axs[2].specgram(in0, NFFT=64, Fs=32, noverlap=8)
              # plt.show()
              
              # Preamble creation
              preamble_up = np.reshape(modulate_vect(self.SF, [0]*self.preamble_len, 1, 1), -1)       # generate preamble_len upchirps
              preamble_down = np.reshape(np.conjugate(modulate_vect(self.SF, [0]*3, 1, 1)), -1)       # generate 3 downchirps
              preamble = np.concatenate((preamble_up, preamble_down[0:int(2.25*pow(2,self.SF))]))     # concatenate preamble_up and preamble_down[0:2.25*M]
          
              corr = np.abs(np.correlate(in0, preamble))**2
              corr_max = np.max(corr)
              corr_max_idx = np.argmax(corr)
              if corr_max > 0.5 :
                  # print(corr_max)
                  pass
                  # print(corr_max)
              if corr_max > self.threshold :
                  print("[RX] Correl. : Correlation threshold exceeded")
                  # print("yes")
                  # print("corr_max_idx", corr_max_idx)
                  # print("len", len(in0))
                  self.state = 1
                  tag_index = self.nitems_written(0) + corr_max_idx + len(preamble)
                  self.add_item_tag(0,tag_index,  pmt.intern("payload_begin"),  pmt.intern(str(self.payload_nitems)))
                  # self.add_item_tag(0,tag_index,  pmt.intern("payload_begin"),  pmt.intern(str(self.preamble_nitems)))
                  self.items_written0_old = self.nitems_written(0)

                  # vect = np.arange(0,len(in0))
                  # plt.plot(vect, np.abs(in0))
                  # plt.axvline(corr_max_idx, 0, 1, color = "red", label = "Corr peak idx")
                  # fig, axs = plt.subplots(3)
                  # axs[0].specgram(in0, NFFT=64, Fs=32, noverlap=8)
                  # axs[0].plot(np.arange(0, len(in0)), in0)
                  # axs[1].plot(np.arange(0, len(corr)), corr)
                  # axs[2].specgram(in0, NFFT=64, Fs=32, noverlap=8)
                  # plt.show()   


              output_items[0][:] = in0[:len(output_items[0])]
              return len(output_items[0])
    payload_nitems: payload_nitems
    preamble_len: preamble_len
    threshold: corr_threshold
  states: {state: disabled}
- name: epy_block_9_0_0
  id: epy_block
  parameters:
    SF: '9'
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import matplotlib.pyplot as plt
      import math

      def modulate_vect(SF, id, os_factor, sign) :
          M  = pow(2,SF)
          ka = np.arange(0,M)
          fact1 = np.exp(1j*sign*math.pi*(pow(ka,2))/M)
          chirp = np.zeros((len(id),M*os_factor), dtype=np.complex64)
          for i in range(len(id)) :
              chirp[i] = fact1*np.exp(2j*math.pi*(id[i]/M)*ka)
          return chirp

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,preamble_len = 6, payload_nitems = 1, threshold = 10000, SF = 1):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='LoRa Correlation Sync Preamble',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              
              self.preamble_len = preamble_len
              self.preamble_nitems = round(pow(2,SF)*(preamble_len+2.25))
              self.payload_nitems = payload_nitems
              self.threshold = threshold
              self.SF = SF

              self.state = 0 # 0 if searching for preamble, 1 if found
              self.items_written0_old = 0
              self.set_output_multiple(self.preamble_nitems + self.payload_nitems + 1000)
              # self.set_history(4224+1)

          def work(self, input_items, output_items):

              in0 = input_items[0]
              # fig, axs = plt.subplots(3)
              # # axs[0].specgram(in0, NFFT=64, Fs=32, noverlap=8)
              # axs[0].plot(np.arange(0, len(in0)), in0)
              # axs[2].specgram(in0, NFFT=64, Fs=32, noverlap=8)
              # plt.show()
              
              # Preamble creation
              preamble_up = np.reshape(modulate_vect(self.SF, [0]*self.preamble_len, 1, 1), -1)       # generate preamble_len upchirps
              preamble_down = np.reshape(np.conjugate(modulate_vect(self.SF, [0]*3, 1, 1)), -1)       # generate 3 downchirps
              preamble = np.concatenate((preamble_up, preamble_down[0:int(2.25*pow(2,self.SF))]))     # concatenate preamble_up and preamble_down[0:2.25*M]
          
              corr = np.abs(np.correlate(in0, preamble))**2
              corr_max = np.max(corr)
              corr_max_idx = np.argmax(corr)
              if corr_max > 0.5 :
                  # print(corr_max)
                  pass
                  # print(corr_max)
              if corr_max > self.threshold :
                  # print("yes")
                  # print("corr_max_idx", corr_max_idx)
                  # print("len", len(in0))
                  self.state = 1
                  tag_index = self.nitems_written(0) + corr_max_idx #+ len(preamble)
                  # self.add_item_tag(0,tag_index,  pmt.intern("payload_begin"),  pmt.intern(str(self.payload_nitems)))
                  self.add_item_tag(0,tag_index,  pmt.intern("preamble_begin"),  pmt.intern(str(self.preamble_nitems)))
                  self.items_written0_old = self.nitems_written(0)

                  # vect = np.arange(0,len(in0))
                  # plt.plot(vect, np.abs(in0))
                  # plt.axvline(corr_max_idx, 0, 1, color = "red", label = "Corr peak idx")
                  # fig, axs = plt.subplots(3)
                  # axs[0].specgram(in0, NFFT=64, Fs=32, noverlap=8)
                  # axs[0].plot(np.arange(0, len(in0)), in0)
                  # axs[1].plot(np.arange(0, len(corr)), corr)
                  # axs[2].specgram(in0, NFFT=64, Fs=32, noverlap=8)
                  # plt.show()   


              output_items[0][:] = in0[:len(output_items[0])]
              return len(output_items[0])
    payload_nitems: payload_nitems
    preamble_len: preamble_len
    threshold: corr_threshold
  states: {state: disabled}
- name: epy_block_9_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import matplotlib.pyplot as plt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,preamble_nitems = 24, payload_nitems = 1, threshold = 10000):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='LoRa Threshold Sync',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              
              self.preamble_nitems = preamble_nitems
              self.payload_nitems = payload_nitems
              self.threshold = threshold
              self.items_written0_old = 0

              self.state = 0 # 0 if searching for preamble, 1 if found
              self.last_tag = 0
              self.set_output_multiple(self.preamble_nitems + self.payload_nitems + 1000)

          def work(self, input_items, output_items):

              in0 = input_items[0][:len(output_items[0])]


              if self.state == 0 :
                  threshold_in0 = np.where(in0 > self.threshold)
                  if len(threshold_in0[0]) > 0:
                      # print("fast : ", threshold_in0[0][0])
                      self.state = 1
                      tag_index = self.nitems_read(0) + threshold_in0[0][0] + 0
                      # print(self.nitems_read(0), threshold_in0[0][0])
                      self.add_item_tag(0,tag_index,  pmt.intern("threshold_exceeded"),  pmt.intern(str(self.preamble_nitems )))
                      self.last_tag = tag_index
                      self.items_written0_old = self.nitems_written(0)
                      # # # debug
                      # vect = np.arange(0,len(in0))
                      # plt.plot(vect, np.real(in0))
                      # plt.axvline(threshold_in0[0][0], 0, 1, color = "red", label = "Corr peak idx")
                      # # plt.specgram(in0, NFFT=64, Fs=32, noverlap=8)
                      # plt.show()
                      

              if self.state == 1 :
                  if self.nitems_written(0) - self.items_written0_old > self.payload_nitems*2:
                      # print("Reset")
                      self.state = 0
                  pass

              output_items[0][:] = in0
              return len(output_items[0])
    payload_nitems: payload_nitems*os_factor
    preamble_nitems: preamble_nitems*os_factor
    threshold: '0.1'
  states: {state: disabled}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: SF
    mask: '0x0F'
    maxsize: payload_len
    minsize: payload_len
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate*2
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: payload_nitems+preamble_nitems+padding
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: center_freq
    center_freq1: center_freq
    clock_source0: gpsdo
    clock_source1: mimo
    dev_addr: '"addr0=192.168.10.3, addr1=192.168.10.2"'
    gain0: gain
    gain1: gain
    nchan: '2'
    num_mboards: '2'
    samp_rate: samp_rate
    sync: none
    time_source1: mimo
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    clock_source0: gpsdo
    dev_addr: '"addr=192.168.10.2"'
    gain0: '0'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    clock_source0: mimo
    dc_offs_enb0: auto
    dev_addr: '"addr=192.168.10.2"'
    gain0: '10'
    iq_imbal_enb0: auto
    samp_rate: samp_rate
    sync: none
    time_source0: mimo
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: input
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: symbols_idx
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: sync_out
  states: {state: disabled}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: Tx
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: Rx
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: input
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: symbols_idx
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: sync_out
  states: {state: disabled}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: Tx
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: Rx
  states: {state: disabled}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://10.10.8.27:5678
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_0_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://10.10.8.27:5679
    timeout: '100'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, pdu_random_pdu_0, generate]
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_4, '0']
- [blocks_stream_demux_0, '0', blocks_file_sink_1, '0']
- [blocks_stream_demux_0, '1', blocks_file_sink_1_0, '0']
- [blocks_stream_mux_0_0, '0', virtual_sink_3, '0']
- [blocks_stream_to_vector_0, '0', epy_block_5, '0']
- [blocks_stream_to_vector_1, '0', blocks_file_sink_0_2_0_0, '0']
- [blocks_stream_to_vector_1, '0', epy_block_6, '1']
- [blocks_tagged_stream_align_0, '0', epy_block_7_0, '0']
- [blocks_tagged_stream_align_1, '0', epy_block_6_0, '0']
- [blocks_tagged_stream_align_1_0, '0', epy_block_6_0_0, '0']
- [blocks_tagged_stream_align_1_0_1, '0', epy_block_6_0_0_1, '0']
- [blocks_tagged_stream_align_1_1, '0', epy_block_6_0_1, '0']
- [blocks_var_to_msg_0, msgout, blocks_message_debug_0, print]
- [blocks_vector_source_x_0, '0', blocks_file_sink_0_3_0_0_0, '0']
- [blocks_vector_source_x_0, '0', virtual_sink_0, '0']
- [blocks_vector_source_x_1_0, '0', blocks_stream_mux_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_tagged_stream_align_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_stream_to_vector_1, '0']
- [channels_channel_model_0, '0', blocks_file_sink_0, '0']
- [channels_channel_model_0, '0', epy_block_9_2, '0']
- [channels_channel_model_0, '0', virtual_sink_4, '0']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_0_1_0_0, '0', blocks_file_sink_0_3_0_0_0_0_1, '0']
- [epy_block_0_1_0_0, '0', epy_block_8, '0']
- [epy_block_1, '0', epy_block_2, '0']
- [epy_block_11, '0', blocks_null_sink_3, '0']
- [epy_block_12, '0', blocks_null_sink_1, '0']
- [epy_block_13, '0', blocks_null_sink_4, '0']
- [epy_block_13, '0', uhd_usrp_sink_0_0, '0']
- [epy_block_13, '1', uhd_usrp_sink_0_0, '1']
- [epy_block_1_0_0, '0', epy_block_1_1, '0']
- [epy_block_1_1, '0', epy_block_0_1_0_0, '0']
- [epy_block_2, '0', blocks_file_sink_0_3_0_0_0_0, '0']
- [epy_block_2, '0', blocks_null_sink_0, '0']
- [epy_block_3, '0', epy_block_6, '0']
- [epy_block_4, '0', blocks_file_sink_0_1_0, '0']
- [epy_block_4, '0', blocks_null_sink_2, '0']
- [epy_block_4_0, '0', blocks_null_sink_2, '0']
- [epy_block_5, '0', epy_block_8_0, '0']
- [epy_block_6, '0', blocks_vector_to_stream_0, '0']
- [epy_block_6_0, '0', virtual_sink_2, '0']
- [epy_block_6_0_0, '0', blocks_file_sink_0_1_0_0, '0']
- [epy_block_6_0_0, '0', epy_block_9_0, '0']
- [epy_block_6_0_0, '0', epy_block_9_0_0, '0']
- [epy_block_6_0_0_0, '0', epy_block_12, '0']
- [epy_block_6_0_0_0_0_0, '0', blocks_vector_to_stream_1, '0']
- [epy_block_6_0_0_1, '0', blocks_file_sink_0_3, '0']
- [epy_block_6_0_0_1, '0', epy_block_11, '0']
- [epy_block_6_0_1, '0', epy_block_12, '0']
- [epy_block_6_0_1, '0', epy_block_4, '0']
- [epy_block_6_0_1, '0', epy_block_4_0, '0']
- [epy_block_6_0_1, '0', epy_block_6_0_0_0, '0']
- [epy_block_7_0, '0', blocks_stream_demux_0, '0']
- [epy_block_7_0, '0', blocks_stream_mux_0_0, '1']
- [epy_block_7_0, '0', epy_block_13, '0']
- [epy_block_7_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_7_0, '0', virtual_sink_3, '0']
- [epy_block_8, '0', virtual_sink_1, '0']
- [epy_block_8_0, '0', blocks_file_sink_0_3_0_0_0_0_0, '0']
- [epy_block_8_0, '0', epy_block_0, '0']
- [epy_block_9, '0', blocks_tagged_stream_align_1_0, '0']
- [epy_block_9_0, '0', blocks_tagged_stream_align_1, '0']
- [epy_block_9_0_0, '0', blocks_tagged_stream_align_1_1, '0']
- [epy_block_9_2, '0', blocks_tagged_stream_align_1_0_1, '0']
- [pdu_pdu_to_stream_x_0, '0', blocks_file_sink_0_3_0_0_0, '0']
- [pdu_pdu_to_stream_x_0, '0', virtual_sink_0, '0']
- [pdu_random_pdu_0, pdus, pdu_pdu_to_stream_x_0, pdus]
- [uhd_usrp_source_1, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_1, '0', virtual_sink_4, '0']
- [virtual_source_0, '0', epy_block_1_0_0, '0']
- [virtual_source_1, '0', epy_block_6_0_0_0_0_0, '0']
- [virtual_source_2, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_3, '0', blocks_file_sink_0_1, '0']
- [virtual_source_3, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_3, '0', channels_channel_model_0, '0']
- [virtual_source_3_0, '0', epy_block_9, '0']
- [zeromq_pull_msg_source_0, out, epy_block_13, h1_est]
- [zeromq_pull_msg_source_0_0, out, epy_block_13, h2_est]

metadata:
  file_format: 1
  grc_version: 3.10.2.0
