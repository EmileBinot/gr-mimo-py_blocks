options:
  parameters:
    generate_options: qt_gui
    id: AoA_USRP
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '868000000'
  states: {}
- name: phase
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '6.283'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_phase_shift_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: phase
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    plotfreq: 'False'
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: center_freq
    center_freq1: center_freq
    clock_source0: gpsdo
    clock_source1: mimo
    dev_addr: '"addr0=192.168.10.3, addr1=192.168.10.2"'
    gain0: '0'
    gain1: '0'
    nchan: '2'
    num_mboards: '2'
    samp_rate: samp_rate
    sync: none
    time_source1: mimo
    type: fc32
  states: {}

connections:
- [blocks_complex_to_real_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_real_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_real_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_phase_shift_0, '0', blocks_complex_to_real_1, '0']
- [uhd_usrp_source_0, '0', blocks_phase_shift_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_1, '0']
- [uhd_usrp_source_0, '1', blocks_complex_to_real_0, '0']
- [uhd_usrp_source_0, '1', qtgui_sink_x_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
