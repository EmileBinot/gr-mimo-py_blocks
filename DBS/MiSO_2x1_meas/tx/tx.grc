options:
  parameters:
    author: ebinot
    generate_options: qt_gui
    id: tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: angle
  id: variable
  parameters:
    value: python_mod.sweeper(fun_prob)
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: int(944.8e6)
  states: {}
- name: fun_prob
  id: variable_function_probe
  parameters:
    block_id: probSign
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: beam_trace
    type: float
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, angle=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32, np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.angle = angle

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0]
              output_items[1][:] = self.angle
              return len(output_items[0])
    angle: angle
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      DBS
      """

      import numpy as np
      from gnuradio import gr
      import math

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, angle=0.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='DBS precoder',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64, np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.angle = angle  # [-90 -> 90]

          def work(self, input_items, output_items):

              self.F = np.transpose([np.exp(-1j*math.pi*math.cos(self.angle*math.pi/180)*np.arange(1,2+1))]) * (1/math.sqrt(2))
              x = [np.transpose(input_items[0])]
              x_precoded = np.matmul(self.F, x)
              
              output_items[0][:] = x_precoded[0]
              output_items[1][:] = x_precoded[1]
              # print(self.F)
              return len(output_items[0])
    angle: angle
  states: {}
- name: probSign
  id: blocks_probe_signal_x
  parameters:
    type: complex
  states: {}
- name: python_mod
  id: epy_module
  parameters:
    source_code: |-
      # this module will be imported in the into your flowgraph

      from locale import ABMON_1
      from termios import FF1


      an1=-180
      an2=180
      angle = an1

      step = 1

      def sweeper(prob_lvl) : 
          global an1,an2,angle, step
          if prob_lvl :
              angle += step

          if angle > an2 :
              angle = an1

          return angle
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: center_freq
    center_freq1: center_freq
    clock_source0: gpsdo
    clock_source1: mimo
    dev_addr: '"addr0=192.168.10.3, addr1=192.168.10.2"'
    gain0: gain
    gain1: gain
    nchan: '2'
    num_mboards: '2'
    samp_rate: samp_rate
    sync: none
    time_source1: mimo
    type: fc32
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://10.10.8.27:5678
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', epy_block_1, '0']
- [analog_sig_source_x_1, '0', probSign, '0']
- [blocks_stream_mux_0, '0', blocks_file_sink_0, '0']
- [epy_block_0, '0', blocks_stream_mux_0, '0']
- [epy_block_0, '0', qtgui_number_sink_0_0, '0']
- [epy_block_0, '1', blocks_stream_mux_0, '1']
- [epy_block_0, '1', qtgui_number_sink_0, '0']
- [epy_block_1, '0', qtgui_time_sink_x_0, '0']
- [epy_block_1, '0', uhd_usrp_sink_0_0, '0']
- [epy_block_1, '1', qtgui_time_sink_x_0, '1']
- [epy_block_1, '1', uhd_usrp_sink_0_0, '1']
- [zeromq_pull_source_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
